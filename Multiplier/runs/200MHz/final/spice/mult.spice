* NGSPICE file created from mult.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

.subckt mult VGND VPWR a[0] a[1] a[2] a[3] a[4] a[5] a[6] a[7] b[0] b[1] b[2] b[3]
+ b[4] b[5] b[6] b[7] clk product[0] product[10] product[11] product[12] product[13]
+ product[14] product[15] product[1] product[2] product[3] product[4] product[5] product[6]
+ product[7] product[8] product[9] rst
XFILLER_39_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0985_ clknet_4_4_0_clk _0055_ _0204_ VGND VGND VPWR VPWR pp\[4\]\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_20_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0770_ net51 VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__inv_2
XFILLER_5_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0968_ clknet_4_1_0_clk _0041_ _0187_ VGND VGND VPWR VPWR pp\[0\]\[2\] sky130_fd_sc_hd__dfrtp_1
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_34_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0899_ clknet_4_5_0_clk net79 _0118_ VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0822_ net43 VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__inv_2
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0684_ _0356_ _0360_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__xnor2_1
X_0753_ net49 VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__inv_2
XFILLER_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1021_ clknet_4_11_0_clk _0102_ _0240_ VGND VGND VPWR VPWR pp\[13\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_0805_ net53 VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__inv_2
X_0667_ net38 net36 _0042_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__and3_1
X_0736_ net49 VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__inv_2
X_0598_ _0375_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__nor2_1
XFILLER_29_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold52 g1\[2\] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 low_sum\[4\] VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 b1\[1\] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold41 _0000_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0452_ net38 b2\[0\] a0\[0\] net35 VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__a22oi_1
X_0521_ pp\[12\]\[0\] _0309_ _0310_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__nand3_1
X_1004_ clknet_4_3_0_clk _0037_ _0223_ VGND VGND VPWR VPWR pp\[9\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0719_ _0440_ _0441_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__and2_1
XFILLER_15_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput31 net31 VGND VGND VPWR VPWR product[7] sky130_fd_sc_hd__buf_2
Xoutput20 net20 VGND VGND VPWR VPWR product[11] sky130_fd_sc_hd__buf_2
XFILLER_16_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0504_ pp\[13\]\[3\] _0298_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_17_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0984_ clknet_4_1_0_clk _0057_ _0203_ VGND VGND VPWR VPWR pp\[4\]\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_6_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0967_ clknet_4_0_0_clk _0040_ _0186_ VGND VGND VPWR VPWR pp\[0\]\[1\] sky130_fd_sc_hd__dfrtp_1
X_0898_ clknet_4_5_0_clk net80 _0117_ VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0752_ net49 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__inv_2
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0821_ net45 VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__inv_2
XFILLER_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0683_ _0359_ _0418_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_0_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
X_1020_ clknet_4_9_0_clk _0104_ _0239_ VGND VGND VPWR VPWR pp\[13\]\[2\] sky130_fd_sc_hd__dfrtp_1
X_0804_ net53 VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__inv_2
X_0735_ net39 VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__inv_2
X_0666_ _0417_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__inv_2
X_0597_ pp\[8\]\[1\] _0369_ _0368_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold42 g5\[4\] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 final_sum\[5\] VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 _0007_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 b2\[1\] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 g3\[5\] VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0451_ net35 net38 _0046_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__and3_1
X_0520_ _0309_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__nand2_1
XFILLER_19_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1003_ clknet_4_3_0_clk _0036_ _0222_ VGND VGND VPWR VPWR pp\[9\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_34_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0718_ high_sum\[14\] _0439_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0649_ b0\[0\] a2\[0\] VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__nand2_1
XFILLER_15_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput21 net21 VGND VGND VPWR VPWR product[12] sky130_fd_sc_hd__buf_2
XFILLER_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput32 net32 VGND VGND VPWR VPWR product[8] sky130_fd_sc_hd__buf_2
XFILLER_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0503_ _0296_ _0297_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_17_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0983_ clknet_4_1_0_clk _0056_ _0202_ VGND VGND VPWR VPWR pp\[4\]\[1\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_19_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0966_ clknet_4_0_0_clk _0038_ _0185_ VGND VGND VPWR VPWR pp\[0\]\[0\] sky130_fd_sc_hd__dfrtp_1
X_0897_ clknet_4_5_0_clk net74 _0116_ VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_2_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_4_Left_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0751_ net39 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__inv_2
XFILLER_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0820_ net42 VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__inv_2
XFILLER_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0682_ _0357_ _0358_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_0_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0949_ clknet_4_6_0_clk _0032_ _0168_ VGND VGND VPWR VPWR g3\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_11_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0803_ net53 VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__inv_2
X_0665_ a0\[0\] b1\[0\] VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__nand2_1
X_0734_ _0043_ _0446_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__nor2_1
X_0596_ pp\[8\]\[2\] _0374_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__xnor2_1
XFILLER_20_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold43 _0004_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 pp\[4\]\[3\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 final_sum\[4\] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 g1\[1\] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 low_sum\[6\] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 g3\[2\] VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Left_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0450_ _0046_ net38 net35 VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__and3b_1
XFILLER_19_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1002_ clknet_4_3_0_clk _0034_ _0221_ VGND VGND VPWR VPWR pp\[9\]\[0\] sky130_fd_sc_hd__dfrtp_1
X_0717_ high_sum\[14\] _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__nand2_1
X_0648_ _0105_ _0409_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__nor2_1
X_0579_ net35 a3\[1\] VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__nand2_1
XFILLER_15_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_33_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput22 net22 VGND VGND VPWR VPWR product[13] sky130_fd_sc_hd__buf_2
Xoutput33 net33 VGND VGND VPWR VPWR product[9] sky130_fd_sc_hd__buf_2
XFILLER_31_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0502_ pp\[10\]\[3\] pp\[7\]\[3\] VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__or2_1
XFILLER_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0982_ clknet_4_1_0_clk _0054_ _0201_ VGND VGND VPWR VPWR pp\[4\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0965_ clknet_4_11_0_clk _0018_ _0184_ VGND VGND VPWR VPWR g5\[4\] sky130_fd_sc_hd__dfrtp_1
X_0896_ clknet_4_5_0_clk net66 _0115_ VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_2_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0681_ pp\[15\]\[2\] net101 VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__or2_1
X_0750_ net39 VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_0_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0948_ clknet_4_6_0_clk _0088_ _0167_ VGND VGND VPWR VPWR g2\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0879_ net39 VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__inv_2
XFILLER_34_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0802_ net54 VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__inv_2
X_0733_ a0\[0\] net36 b1\[0\] net38 VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__a22oi_1
X_0664_ net38 b0\[1\] _0038_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__and3_1
XFILLER_37_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0595_ pp\[5\]\[2\] pp\[2\]\[2\] VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__xor2_1
Xhold11 low_sum\[5\] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 final_sum\[10\] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 g4\[3\] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 _0352_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 _0006_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 _0011_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1001_ clknet_4_6_0_clk _0110_ _0220_ VGND VGND VPWR VPWR pp\[8\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_0578_ _0362_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__inv_2
X_0716_ net119 _0437_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__xnor2_1
X_0647_ _0408_ _0409_ _0410_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__o21a_1
XFILLER_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput23 net23 VGND VGND VPWR VPWR product[14] sky130_fd_sc_hd__buf_2
X_0501_ pp\[10\]\[3\] pp\[7\]\[3\] VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__nand2_1
XFILLER_39_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0981_ clknet_4_8_0_clk _0051_ _0200_ VGND VGND VPWR VPWR pp\[3\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0964_ clknet_4_14_0_clk _0022_ _0183_ VGND VGND VPWR VPWR g5\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_34_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0895_ clknet_4_0_0_clk net71 _0114_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_2_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0680_ g5\[3\] g4\[5\] net107 VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_0_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0947_ clknet_4_7_0_clk _0092_ _0166_ VGND VGND VPWR VPWR g2\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_30_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0878_ net41 VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__inv_2
XFILLER_34_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload0 clknet_4_0_0_clk VGND VGND VPWR VPWR clkload0/X sky130_fd_sc_hd__clkbuf_4
X_0801_ net54 VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__inv_2
XFILLER_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0732_ net38 net36 _0417_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__and3_1
X_0663_ _0416_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__inv_2
X_0594_ pp\[5\]\[2\] pp\[2\]\[2\] VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__and2_1
XFILLER_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold45 _0001_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 g1\[0\] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 final_sum\[1\] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 g3\[3\] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 final_sum\[8\] VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold67 a0\[1\] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd3_1
X_1000_ clknet_4_6_0_clk _0112_ _0219_ VGND VGND VPWR VPWR pp\[8\]\[2\] sky130_fd_sc_hd__dfrtp_1
X_0715_ _0432_ _0436_ high_sum\[12\] high_sum\[13\] VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__o211a_1
X_0577_ b2\[0\] a3\[0\] VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__nand2_1
X_0646_ b0\[0\] a3\[1\] a3\[0\] b0\[1\] VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__a22o_1
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput24 net24 VGND VGND VPWR VPWR product[15] sky130_fd_sc_hd__buf_2
XFILLER_0_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0500_ _0291_ _0294_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0629_ pp\[11\]\[1\] pp\[14\]\[1\] VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_23_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0980_ clknet_4_3_0_clk _0053_ _0199_ VGND VGND VPWR VPWR pp\[3\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0963_ clknet_4_11_0_clk _0021_ _0182_ VGND VGND VPWR VPWR g5\[2\] sky130_fd_sc_hd__dfrtp_1
X_0894_ clknet_4_1_0_clk net85 _0113_ VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_2_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0877_ net54 VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__inv_2
X_0946_ clknet_4_6_0_clk _0091_ _0165_ VGND VGND VPWR VPWR g2\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_30_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload1 clknet_4_1_0_clk VGND VGND VPWR VPWR clkload1/X sky130_fd_sc_hd__clkbuf_8
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0800_ net53 VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__inv_2
X_0731_ _0039_ _0445_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__nor2_1
X_0662_ a0\[0\] b0\[0\] VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__nand2_1
X_0593_ _0370_ _0371_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__xnor2_1
XFILLER_37_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0929_ clknet_4_4_0_clk net114 _0148_ VGND VGND VPWR VPWR low_sum\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold68 pp\[11\]\[3\] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 pp\[15\]\[0\] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 pp\[0\]\[0\] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 _0005_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 _0012_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 final_sum\[11\] VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0714_ _0437_ _0438_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__and2_1
X_0645_ _0408_ _0409_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__nor2_1
X_0576_ net125 _0361_ _0351_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__o21bai_1
XFILLER_15_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput25 net25 VGND VGND VPWR VPWR product[1] sky130_fd_sc_hd__buf_2
XFILLER_30_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0628_ _0397_ _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__nor2_1
XFILLER_7_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0559_ _0335_ _0337_ _0345_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__o21ai_1
XFILLER_13_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0962_ clknet_4_14_0_clk _0020_ _0181_ VGND VGND VPWR VPWR g5\[1\] sky130_fd_sc_hd__dfrtp_1
X_0893_ net48 VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__inv_2
XFILLER_4_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_24_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0876_ net54 VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__inv_2
X_0945_ clknet_4_7_0_clk _0090_ _0164_ VGND VGND VPWR VPWR g2\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_18_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload2 clknet_4_2_0_clk VGND VGND VPWR VPWR clkload2/X sky130_fd_sc_hd__clkbuf_4
X_0730_ a0\[0\] b0\[1\] b0\[0\] net38 VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__a22oi_1
X_0661_ net36 a2\[1\] _0034_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__and3_1
X_0592_ _0370_ _0371_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__and2b_1
XFILLER_37_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0928_ clknet_4_4_0_clk net116 _0147_ VGND VGND VPWR VPWR low_sum\[2\] sky130_fd_sc_hd__dfrtp_1
X_0859_ net47 VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__inv_2
Xhold58 high_sum\[15\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 final_sum\[12\] VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 _0002_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 g1\[3\] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 low_sum\[2\] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0713_ high_sum\[12\] _0432_ _0436_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__or3_1
X_0644_ b0\[1\] a3\[1\] VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_27_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0575_ _0355_ _0360_ _0354_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_11_Left_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput26 net26 VGND VGND VPWR VPWR product[2] sky130_fd_sc_hd__buf_2
XFILLER_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0627_ pp\[11\]\[2\] pp\[14\]\[2\] VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__nor2_1
X_0558_ _0335_ _0337_ _0345_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__o21a_1
X_0489_ pp\[10\]\[2\] pp\[7\]\[2\] VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_14_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0961_ clknet_4_14_0_clk _0019_ _0180_ VGND VGND VPWR VPWR g5\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_42_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0892_ net45 VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__inv_2
XFILLER_4_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout50 net59 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0944_ clknet_4_5_0_clk _0089_ _0163_ VGND VGND VPWR VPWR g2\[1\] sky130_fd_sc_hd__dfrtp_1
X_0875_ net54 VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_41_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload3 clknet_4_3_0_clk VGND VGND VPWR VPWR clkload3/X sky130_fd_sc_hd__clkbuf_4
XFILLER_40_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0591_ pp\[8\]\[0\] _0366_ _0365_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__a21bo_1
X_0660_ _0415_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__inv_2
XFILLER_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0927_ clknet_4_0_0_clk net88 _0146_ VGND VGND VPWR VPWR low_sum\[1\] sky130_fd_sc_hd__dfrtp_1
X_0789_ net50 VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__inv_2
X_0858_ net47 VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__inv_2
Xhold48 pp\[15\]\[1\] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 final_sum\[3\] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 final_sum\[0\] VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 _0008_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 pp\[8\]\[0\] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_36_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0712_ _0432_ _0436_ high_sum\[12\] VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__o21ai_1
X_0574_ pp\[1\]\[1\] pp\[4\]\[1\] _0359_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__a21oi_1
X_0643_ _0408_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__inv_2
XFILLER_25_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput27 net27 VGND VGND VPWR VPWR product[3] sky130_fd_sc_hd__buf_2
XFILLER_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_7_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0626_ pp\[11\]\[2\] pp\[14\]\[2\] VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0557_ pp\[9\]\[3\] _0333_ _0332_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0488_ pp\[10\]\[2\] pp\[7\]\[2\] VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__and2_1
XFILLER_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0609_ _0377_ _0379_ _0386_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__o21ba_1
XFILLER_17_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0960_ clknet_4_14_0_clk _0074_ _0179_ VGND VGND VPWR VPWR g4\[5\] sky130_fd_sc_hd__dfrtp_1
X_0891_ net41 VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__inv_2
XFILLER_23_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout51 net52 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_4
Xfanout40 net42 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_2
XFILLER_13_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0874_ net54 VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__inv_2
Xclkload10 clknet_4_11_0_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__clkinv_4
X_0943_ clknet_4_4_0_clk _0033_ _0162_ VGND VGND VPWR VPWR g2\[0\] sky130_fd_sc_hd__dfrtp_1
Xclkload4 clknet_4_4_0_clk VGND VGND VPWR VPWR clkload4/X sky130_fd_sc_hd__clkbuf_4
XFILLER_24_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0590_ pp\[8\]\[1\] _0369_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__xnor2_1
XFILLER_1_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0926_ clknet_4_0_0_clk net72 _0145_ VGND VGND VPWR VPWR low_sum\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0857_ net47 VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__inv_2
Xhold16 final_sum\[14\] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 g2\[3\] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dlygate4sd3_1
X_0788_ net50 VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__inv_2
Xhold27 g3\[4\] VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 _0003_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_19_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0711_ _0434_ _0435_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__xor2_1
X_0573_ pp\[1\]\[0\] pp\[4\]\[0\] _0357_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__and3_1
X_0642_ b0\[0\] a3\[0\] VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__nand2_1
X_0909_ clknet_4_15_0_clk net65 _0128_ VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dfrtp_1
Xoutput28 net28 VGND VGND VPWR VPWR product[4] sky130_fd_sc_hd__buf_2
XFILLER_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0625_ _0394_ _0395_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nor2_1
XFILLER_7_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0556_ _0328_ _0330_ _0341_ _0343_ _0340_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__o311a_1
X_0487_ net121 _0283_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__xnor2_1
X_1039_ clknet_4_0_0_clk net2 _0258_ VGND VGND VPWR VPWR a0\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_42_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0608_ _0383_ _0384_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__xnor2_1
XFILLER_37_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0539_ pp\[12\]\[1\] _0325_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__xnor2_1
XFILLER_26_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0890_ net45 VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_10_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout52 net59 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_2
Xfanout41 net42 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_4
XFILLER_13_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0873_ net54 VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__inv_2
X_0942_ clknet_4_5_0_clk _0013_ _0161_ VGND VGND VPWR VPWR g1\[4\] sky130_fd_sc_hd__dfrtp_1
Xclkload11 clknet_4_12_0_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__clkinv_2
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload5 clknet_4_6_0_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__clkinvlp_4
X_0925_ clknet_4_15_0_clk _0030_ _0144_ VGND VGND VPWR VPWR final_sum\[15\] sky130_fd_sc_hd__dfrtp_1
X_0856_ net47 VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__inv_2
X_0787_ net50 VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__inv_2
Xhold28 low_sum\[0\] VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 final_sum\[6\] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 _0010_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_36_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0641_ _0101_ _0406_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__nor2_1
X_0710_ _0428_ _0430_ _0434_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__o21ba_1
X_0572_ pp\[1\]\[0\] pp\[4\]\[0\] VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__nand2_1
XFILLER_25_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0908_ clknet_4_15_0_clk net75 _0127_ VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dfrtp_1
Xoutput29 net29 VGND VGND VPWR VPWR product[5] sky130_fd_sc_hd__buf_2
Xoutput18 net18 VGND VGND VPWR VPWR product[0] sky130_fd_sc_hd__buf_2
XFILLER_0_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0839_ net44 VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__inv_2
XFILLER_21_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0624_ net127 pp\[14\]\[3\] VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_15_Left_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0555_ _0338_ _0339_ _0321_ _0326_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__a211o_1
X_0486_ _0281_ _0282_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1038_ clknet_4_2_0_clk net1 _0257_ VGND VGND VPWR VPWR a0\[0\] sky130_fd_sc_hd__dfrtp_2
XFILLER_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0607_ _0383_ _0384_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__nor2_1
X_0538_ _0321_ _0326_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__xnor2_1
X_0469_ b2\[0\] a1\[0\] VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__and2_1
XFILLER_26_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout42 net59 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_2
Xfanout53 net55 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_0_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0941_ clknet_4_5_0_clk _0017_ _0160_ VGND VGND VPWR VPWR g1\[3\] sky130_fd_sc_hd__dfrtp_1
Xclkload12 clknet_4_14_0_clk VGND VGND VPWR VPWR clkload12/X sky130_fd_sc_hd__clkbuf_4
X_0872_ net57 VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__inv_2
XFILLER_34_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload6 clknet_4_7_0_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinv_2
XFILLER_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Left_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0924_ clknet_4_15_0_clk _0029_ _0143_ VGND VGND VPWR VPWR final_sum\[14\] sky130_fd_sc_hd__dfrtp_1
X_0786_ net50 VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__inv_2
X_0855_ net47 VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__inv_2
Xhold18 final_sum\[13\] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 pp\[0\]\[1\] VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0571_ pp\[1\]\[1\] pp\[4\]\[1\] VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__xor2_1
X_0640_ _0405_ _0406_ _0407_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__o21a_1
X_0907_ clknet_4_15_0_clk net77 _0126_ VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dfrtp_1
X_0769_ net49 VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__inv_2
X_0838_ net49 VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__inv_2
Xoutput19 net19 VGND VGND VPWR VPWR product[10] sky130_fd_sc_hd__buf_2
XFILLER_24_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Left_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0623_ pp\[11\]\[3\] pp\[14\]\[3\] VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__and2_1
XFILLER_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0554_ _0341_ _0342_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__xnor2_1
X_0485_ pp\[10\]\[0\] pp\[7\]\[0\] VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__or2_1
XFILLER_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1037_ clknet_4_14_0_clk net62 _0256_ VGND VGND VPWR VPWR high_sum\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_16_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_244 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0606_ pp\[8\]\[2\] _0374_ _0373_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__a21oi_1
X_0537_ _0321_ _0326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__or2_1
X_0468_ _0059_ _0277_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__nor2_1
XFILLER_17_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout43 net44 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_4
Xfanout54 net55 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0940_ clknet_4_4_0_clk _0016_ _0159_ VGND VGND VPWR VPWR g1\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload13 clknet_4_15_0_clk VGND VGND VPWR VPWR clkload13/X sky130_fd_sc_hd__clkbuf_8
X_0871_ net56 VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__inv_2
Xclkload7 clknet_4_8_0_clk VGND VGND VPWR VPWR clkload7/X sky130_fd_sc_hd__clkbuf_4
XFILLER_24_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0923_ clknet_4_15_0_clk _0028_ _0142_ VGND VGND VPWR VPWR final_sum\[13\] sky130_fd_sc_hd__dfrtp_1
X_0854_ net44 VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__inv_2
X_0785_ net50 VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__inv_2
Xhold19 low_sum\[1\] VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0570_ _0354_ _0355_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__nor2_1
XFILLER_32_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1053_ clknet_4_8_0_clk net16 _0272_ VGND VGND VPWR VPWR b3\[1\] sky130_fd_sc_hd__dfrtp_1
X_0906_ clknet_4_15_0_clk net84 _0125_ VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dfrtp_1
X_0837_ net46 VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__inv_2
X_0768_ net49 VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__inv_2
X_0699_ _0425_ _0426_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__nor2_1
XFILLER_24_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0622_ _0093_ _0392_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__nor2_1
X_0553_ _0328_ _0330_ _0327_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__o21ai_1
X_0484_ pp\[10\]\[0\] pp\[7\]\[0\] VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__nand2_1
XFILLER_38_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1036_ clknet_4_14_0_clk net102 _0255_ VGND VGND VPWR VPWR high_sum\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_29_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0467_ a1\[0\] net36 b1\[0\] net37 VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__a22oi_1
X_0605_ pp\[8\]\[3\] _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__xor2_1
X_0536_ pp\[12\]\[1\] _0325_ _0324_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_36_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1019_ clknet_4_9_0_clk _0103_ _0238_ VGND VGND VPWR VPWR pp\[13\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_27_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0519_ _0307_ _0308_ pp\[9\]\[0\] VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__a21o_1
Xfanout44 net59 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_4
Xfanout55 net58 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_24_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0870_ net56 VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_30_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0999_ clknet_4_3_0_clk _0111_ _0218_ VGND VGND VPWR VPWR pp\[8\]\[1\] sky130_fd_sc_hd__dfrtp_1
Xclkload8 clknet_4_9_0_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__bufinv_16
XFILLER_39_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0853_ net48 VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__inv_2
X_0922_ clknet_4_15_0_clk _0027_ _0141_ VGND VGND VPWR VPWR final_sum\[12\] sky130_fd_sc_hd__dfrtp_1
X_0784_ net51 VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__inv_2
Xinput1 a[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1052_ clknet_4_8_0_clk net15 _0271_ VGND VGND VPWR VPWR b3\[0\] sky130_fd_sc_hd__dfrtp_4
XFILLER_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0767_ net39 VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__inv_2
X_0836_ net45 VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__inv_2
X_0905_ clknet_4_13_0_clk net83 _0124_ VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0698_ high_sum\[8\] low_sum\[8\] _0423_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__and3_1
XFILLER_21_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0621_ _0391_ _0392_ _0393_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__o21a_1
XFILLER_7_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0552_ _0338_ _0339_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__xnor2_1
X_0483_ _0071_ _0280_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__nor2_1
X_1035_ clknet_4_14_0_clk net108 _0254_ VGND VGND VPWR VPWR high_sum\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0819_ net41 VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__inv_2
XFILLER_16_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0604_ _0380_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__nand2_1
X_0466_ net37 net36 _0058_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__and3_1
X_0535_ _0322_ _0323_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_36_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1018_ clknet_4_9_0_clk _0101_ _0237_ VGND VGND VPWR VPWR pp\[13\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_43_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0518_ pp\[9\]\[0\] _0307_ _0308_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__nand3_1
X_0449_ b2\[0\] a0\[0\] VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__and2_1
Xfanout45 net46 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_24_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout56 net58 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_4
Xfanout34 b3\[1\] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_2
XFILLER_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload9 clknet_4_10_0_clk VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__bufinv_16
X_0998_ clknet_4_6_0_clk _0109_ _0217_ VGND VGND VPWR VPWR pp\[8\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0921_ clknet_4_13_0_clk _0026_ _0140_ VGND VGND VPWR VPWR final_sum\[11\] sky130_fd_sc_hd__dfrtp_1
X_0852_ net47 VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__inv_2
X_0783_ net50 VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__inv_2
Xinput2 a[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1051_ clknet_4_2_0_clk net14 _0270_ VGND VGND VPWR VPWR b2\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0904_ clknet_4_13_0_clk net81 _0123_ VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dfrtp_1
X_0766_ net40 VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__inv_2
X_0697_ _0423_ _0424_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__and2b_1
X_0835_ net45 VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_19_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0620_ b3\[0\] a2\[1\] a2\[0\] net34 VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__a22o_1
XFILLER_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0551_ _0338_ _0339_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__or2_1
XFILLER_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0482_ b2\[0\] a2\[1\] a2\[0\] net35 VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__a22oi_1
X_1034_ clknet_4_15_0_clk net106 _0253_ VGND VGND VPWR VPWR high_sum\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_21_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0749_ net57 VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_8_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0818_ net42 VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__inv_2
XFILLER_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0603_ pp\[5\]\[3\] pp\[2\]\[3\] VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__or2_1
X_0534_ _0323_ _0322_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__and2b_1
X_0465_ _0058_ net36 net37 VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_36_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1017_ clknet_4_9_0_clk _0106_ _0236_ VGND VGND VPWR VPWR pp\[12\]\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_4_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0517_ pp\[6\]\[0\] pp\[3\]\[0\] VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__or2_1
X_0448_ net43 VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__inv_2
XFILLER_14_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout35 b2\[1\] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_2
XFILLER_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout46 net48 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_4
Xfanout57 net58 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_30_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0997_ clknet_4_8_0_clk _0067_ _0216_ VGND VGND VPWR VPWR pp\[7\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0920_ clknet_4_13_0_clk _0025_ _0139_ VGND VGND VPWR VPWR final_sum\[10\] sky130_fd_sc_hd__dfrtp_1
X_0851_ net47 VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__inv_2
X_0782_ net49 VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 a[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1050_ clknet_4_8_0_clk net13 _0269_ VGND VGND VPWR VPWR b2\[0\] sky130_fd_sc_hd__dfrtp_4
XFILLER_33_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0903_ clknet_4_13_0_clk net64 _0122_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dfrtp_1
X_0834_ net45 VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__inv_2
XFILLER_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0765_ net57 VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__inv_2
X_0696_ high_sum\[8\] low_sum\[8\] VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_19_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0550_ _0273_ _0320_ _0319_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__o21a_1
XFILLER_38_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0481_ net123 a2\[1\] _0070_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__and3_1
X_1033_ clknet_4_14_0_clk net104 _0252_ VGND VGND VPWR VPWR high_sum\[11\] sky130_fd_sc_hd__dfrtp_1
X_0817_ net41 VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__inv_2
XFILLER_21_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_26_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0748_ net57 VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__inv_2
X_0679_ g5\[2\] g4\[4\] net105 VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_10_Left_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0464_ a1\[0\] b1\[0\] VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__and2_1
X_0602_ pp\[5\]\[3\] pp\[2\]\[3\] VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__nand2_1
X_0533_ pp\[9\]\[1\] _0317_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_36_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1016_ clknet_4_9_0_clk _0108_ _0235_ VGND VGND VPWR VPWR pp\[12\]\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_4_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0516_ pp\[6\]\[0\] pp\[3\]\[0\] VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__nand2_1
X_0447_ pp\[12\]\[2\] VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__inv_2
Xfanout36 b1\[1\] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_2
Xfanout47 net48 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_4
Xfanout58 net59 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_2
XFILLER_1_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0996_ clknet_4_9_0_clk _0069_ _0215_ VGND VGND VPWR VPWR pp\[7\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0850_ net47 VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__inv_2
X_0781_ net51 VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__inv_2
XFILLER_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput4 a[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
XFILLER_36_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0979_ clknet_4_2_0_clk _0052_ _0198_ VGND VGND VPWR VPWR pp\[3\]\[1\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_40_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0902_ clknet_4_13_0_clk net82 _0121_ VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dfrtp_1
X_0833_ net45 VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__inv_2
X_0764_ net57 VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__inv_2
X_0695_ high_sum\[9\] low_sum\[9\] VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__xor2_1
XFILLER_21_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0480_ _0070_ a2\[1\] net35 VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__and3b_1
XFILLER_38_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1032_ clknet_4_15_0_clk net100 _0251_ VGND VGND VPWR VPWR high_sum\[10\] sky130_fd_sc_hd__dfrtp_1
X_0747_ net57 VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__inv_2
X_0816_ net41 VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__inv_2
X_0678_ g2\[1\] net95 VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__or2_1
XFILLER_32_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0601_ _0372_ _0378_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__xnor2_1
X_0463_ _0055_ _0276_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__nor2_1
X_0532_ pp\[9\]\[0\] _0308_ _0307_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__a21bo_1
XFILLER_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1015_ clknet_4_3_0_clk _0107_ _0234_ VGND VGND VPWR VPWR pp\[12\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_26_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0515_ _0292_ _0293_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__xnor2_1
Xfanout37 a1\[1\] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_2
Xfanout59 net17 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_2
Xfanout48 net59 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_2
XFILLER_38_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0995_ clknet_4_8_0_clk _0068_ _0214_ VGND VGND VPWR VPWR pp\[7\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0780_ net49 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__inv_2
Xinput5 a[4] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0978_ clknet_4_2_0_clk _0050_ _0197_ VGND VGND VPWR VPWR pp\[3\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_19_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0763_ net58 VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__inv_2
X_0901_ clknet_4_7_0_clk net67 _0120_ VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__dfrtp_1
X_0832_ net42 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__inv_2
X_0694_ high_sum\[9\] low_sum\[9\] VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__and2_1
XFILLER_24_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
X_1031_ clknet_4_13_0_clk net60 _0250_ VGND VGND VPWR VPWR high_sum\[9\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_16_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0746_ net57 VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__inv_2
X_0815_ net41 VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__inv_2
X_0677_ g2\[0\] net111 VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__or2_1
XFILLER_12_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0600_ _0370_ _0378_ _0371_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__nor3b_1
XFILLER_11_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0531_ _0273_ _0320_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__xnor2_1
X_0462_ net37 b0\[0\] a1\[0\] b0\[1\] VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__a22oi_1
X_1014_ clknet_4_6_0_clk _0105_ _0233_ VGND VGND VPWR VPWR pp\[12\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0729_ net38 b0\[1\] _0416_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_4_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0514_ _0074_ _0306_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__nor2_1
Xfanout38 a0\[1\] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_2
Xfanout49 net50 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_32_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0994_ clknet_4_9_0_clk _0066_ _0213_ VGND VGND VPWR VPWR pp\[7\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput6 a[5] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0977_ clknet_4_2_0_clk _0047_ _0196_ VGND VGND VPWR VPWR pp\[2\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_27_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0900_ clknet_4_7_0_clk net76 _0119_ VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0693_ _0401_ _0421_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__and2_1
X_0762_ net57 VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__inv_2
X_0831_ net45 VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1030_ clknet_4_13_0_clk net61 _0249_ VGND VGND VPWR VPWR high_sum\[8\] sky130_fd_sc_hd__dfrtp_1
X_0814_ net40 VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_16_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0676_ net93 g2\[5\] VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__or2_1
X_0745_ net57 VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_39_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0530_ _0315_ _0318_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_21_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0461_ b0\[1\] net37 _0054_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__and3_1
X_1013_ clknet_4_10_0_clk _0094_ _0232_ VGND VGND VPWR VPWR pp\[11\]\[3\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_14_Left_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0659_ b1\[0\] a2\[0\] VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__nand2_1
X_0728_ _0035_ _0444_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__nor2_1
XFILLER_27_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_10_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0513_ _0301_ _0303_ _0305_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__nor3_1
Xfanout39 net42 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_4
XFILLER_22_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0993_ clknet_4_2_0_clk _0063_ _0212_ VGND VGND VPWR VPWR pp\[6\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput7 a[6] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
X_0976_ clknet_4_3_0_clk _0049_ _0195_ VGND VGND VPWR VPWR pp\[2\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_2_Left_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0830_ net42 VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__inv_2
X_0761_ net57 VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__inv_2
X_0692_ pp\[11\]\[0\] pp\[14\]\[0\] VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__or2_1
XFILLER_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0959_ clknet_4_11_0_clk _0078_ _0178_ VGND VGND VPWR VPWR g4\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput10 b[1] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
X_0813_ net49 VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__inv_2
XFILLER_14_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0675_ net91 g2\[4\] VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__or2_1
X_0744_ net56 VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_39_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0460_ _0054_ net37 b0\[1\] VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__and3b_1
X_1012_ clknet_4_10_0_clk _0096_ _0231_ VGND VGND VPWR VPWR pp\[11\]\[2\] sky130_fd_sc_hd__dfrtp_1
X_0727_ b1\[0\] a2\[1\] a2\[0\] net122 VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__a22oi_1
X_0658_ net34 a3\[1\] _0097_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__and3_1
X_0589_ pp\[5\]\[1\] pp\[2\]\[1\] VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__xor2_1
XFILLER_27_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_31_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0512_ _0301_ _0303_ _0305_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__o21a_1
XFILLER_22_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0992_ clknet_4_3_0_clk _0065_ _0211_ VGND VGND VPWR VPWR pp\[6\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput8 a[7] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_36_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0975_ clknet_4_3_0_clk _0048_ _0194_ VGND VGND VPWR VPWR pp\[2\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0760_ net58 VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__inv_2
X_0691_ _0396_ _0404_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__xnor2_1
XFILLER_2_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0889_ net39 VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__inv_2
XFILLER_21_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0958_ clknet_4_14_0_clk _0077_ _0177_ VGND VGND VPWR VPWR g4\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0812_ net43 VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__inv_2
Xinput11 b[2] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
X_0743_ net56 VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__inv_2
X_0674_ g3\[1\] net97 VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__or2_1
XFILLER_29_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1011_ clknet_4_10_0_clk _0095_ _0230_ VGND VGND VPWR VPWR pp\[11\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0726_ net36 a2\[1\] _0415_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__and3_1
X_0657_ _0414_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__inv_2
X_0588_ pp\[5\]\[1\] pp\[2\]\[1\] VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__and2_1
XFILLER_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0511_ pp\[13\]\[3\] _0297_ _0296_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__a21bo_1
XFILLER_13_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0709_ _0428_ _0430_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__nor2_1
XFILLER_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0991_ clknet_4_2_0_clk _0064_ _0210_ VGND VGND VPWR VPWR pp\[6\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput9 b[0] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
X_0974_ clknet_4_0_0_clk _0046_ _0193_ VGND VGND VPWR VPWR pp\[2\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_19_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0690_ _0399_ _0403_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__xnor2_1
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0888_ net40 VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__inv_2
X_0957_ clknet_4_12_0_clk _0076_ _0176_ VGND VGND VPWR VPWR g4\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_11_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0811_ net43 VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__inv_2
Xinput12 b[3] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
X_0673_ g2\[2\] g1\[4\] net109 VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__or3_1
X_0742_ net56 VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__inv_2
XFILLER_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1010_ clknet_4_10_0_clk _0093_ _0229_ VGND VGND VPWR VPWR pp\[11\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_34_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0725_ _0098_ _0443_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__nor2_1
X_0656_ b3\[0\] a3\[0\] VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__nand2_1
X_0587_ net118 _0367_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__xnor2_1
XFILLER_27_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0510_ _0303_ _0304_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__and2b_1
Xhold1 g4\[1\] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0639_ b1\[0\] a3\[1\] a3\[0\] net36 VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__a22o_1
X_0708_ _0432_ _0433_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__or2_1
XFILLER_13_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0990_ clknet_4_2_0_clk _0062_ _0209_ VGND VGND VPWR VPWR pp\[6\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_1_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0973_ clknet_4_4_0_clk _0043_ _0192_ VGND VGND VPWR VPWR pp\[1\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_42_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0956_ clknet_4_12_0_clk _0075_ _0175_ VGND VGND VPWR VPWR g4\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0887_ net39 VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__inv_2
XFILLER_11_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0810_ net43 VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__inv_2
Xinput13 b[4] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
X_0672_ net113 pp\[0\]\[3\] VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__or2_1
X_0741_ net52 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__inv_2
XFILLER_37_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0939_ clknet_4_4_0_clk _0015_ _0158_ VGND VGND VPWR VPWR g1\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_11_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0724_ b3\[0\] a3\[1\] a3\[0\] b3\[1\] VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__a22oi_1
X_0586_ _0365_ _0366_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__nand2_1
X_0655_ _0109_ _0412_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__nor2_1
XFILLER_40_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Left_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold2 g4\[0\] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__dlygate4sd3_1
X_0707_ high_sum\[11\] low_sum\[11\] VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__nor2_1
X_0569_ pp\[1\]\[2\] pp\[4\]\[2\] VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__nor2_1
X_0638_ _0405_ _0406_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_35_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_1_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0972_ clknet_4_4_0_clk _0045_ _0191_ VGND VGND VPWR VPWR pp\[1\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0886_ net41 VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__inv_2
X_0955_ clknet_4_12_0_clk _0031_ _0174_ VGND VGND VPWR VPWR g4\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_32_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0740_ net51 VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__inv_2
XFILLER_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput14 b[5] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
X_0671_ net115 pp\[0\]\[2\] VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__or2_1
XFILLER_37_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0869_ net54 VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__inv_2
X_0938_ clknet_4_4_0_clk _0014_ _0157_ VGND VGND VPWR VPWR g1\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0723_ net34 a3\[1\] _0414_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__and3_1
X_0585_ pp\[5\]\[0\] pp\[2\]\[0\] VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__or2_1
X_0654_ _0411_ _0412_ _0413_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__o21a_1
XFILLER_43_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold3 pp\[15\]\[3\] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
X_0706_ high_sum\[11\] low_sum\[11\] VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__and2_1
XFILLER_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0568_ pp\[1\]\[2\] pp\[4\]\[2\] VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__and2_1
X_0637_ net36 a3\[1\] VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__nand2_1
X_0499_ _0291_ _0294_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__and2b_1
XFILLER_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0971_ clknet_4_1_0_clk _0044_ _0190_ VGND VGND VPWR VPWR pp\[1\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0885_ net45 VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__inv_2
X_0954_ clknet_4_12_0_clk _0079_ _0173_ VGND VGND VPWR VPWR g3\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_11_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput15 b[6] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
X_0670_ g5\[1\] net103 VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_15_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0868_ net53 VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__inv_2
X_0799_ net53 VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__inv_2
X_0937_ clknet_4_12_0_clk net90 _0156_ VGND VGND VPWR VPWR low_sum\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_43_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0653_ b0\[0\] a2\[1\] a2\[0\] b0\[1\] VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__a22o_1
X_0722_ _0424_ _0442_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__and2_1
XFILLER_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0584_ pp\[5\]\[0\] pp\[2\]\[0\] VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_26_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold4 low_sum\[7\] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_32_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0636_ _0405_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__inv_2
X_0705_ _0430_ _0431_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__and2b_1
X_0567_ _0351_ _0352_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__nor2_1
X_0498_ _0292_ _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0619_ _0391_ _0392_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__nor2_1
XFILLER_5_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_29_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0970_ clknet_4_1_0_clk _0042_ _0189_ VGND VGND VPWR VPWR pp\[1\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0953_ clknet_4_12_0_clk _0083_ _0172_ VGND VGND VPWR VPWR g3\[4\] sky130_fd_sc_hd__dfrtp_1
X_0884_ net45 VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__inv_2
XFILLER_23_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput16 b[7] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_15_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0936_ clknet_4_12_0_clk net86 _0155_ VGND VGND VPWR VPWR low_sum\[10\] sky130_fd_sc_hd__dfrtp_1
X_0867_ net53 VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__inv_2
X_0798_ net53 VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_38_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0583_ _0084_ _0363_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__nor2_1
XFILLER_10_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0652_ _0411_ _0412_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__nor2_1
X_0721_ high_sum\[8\] low_sum\[8\] VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__or2_1
X_0919_ clknet_4_13_0_clk _0024_ _0138_ VGND VGND VPWR VPWR final_sum\[9\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_26_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold5 final_sum\[9\] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_30_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0566_ pp\[1\]\[3\] net124 VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__nor2_1
X_0635_ b1\[0\] a3\[0\] VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__nand2_1
X_0704_ _0427_ _0429_ _0422_ _0426_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__a211o_1
X_0497_ pp\[13\]\[0\] _0282_ _0281_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__a21bo_1
X_1049_ clknet_4_0_0_clk net12 _0268_ VGND VGND VPWR VPWR b1\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0618_ net34 a2\[1\] VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__nand2_1
X_0549_ pp\[12\]\[3\] _0336_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__xnor2_1
XFILLER_14_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0952_ clknet_4_12_0_clk _0082_ _0171_ VGND VGND VPWR VPWR g3\[3\] sky130_fd_sc_hd__dfrtp_1
X_0883_ net41 VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__inv_2
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
Xinput17 rst VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
XFILLER_28_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0866_ net53 VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_15_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0935_ clknet_4_13_0_clk net94 _0154_ VGND VGND VPWR VPWR low_sum\[9\] sky130_fd_sc_hd__dfrtp_1
X_0797_ net53 VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_38_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0720_ net117 _0440_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__xnor2_1
X_0582_ _0362_ _0363_ _0364_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__o21a_1
XFILLER_10_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0651_ b0\[1\] a2\[1\] VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_43_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0918_ clknet_4_13_0_clk _0023_ _0137_ VGND VGND VPWR VPWR final_sum\[8\] sky130_fd_sc_hd__dfrtp_1
X_0849_ net46 VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_26_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold6 final_sum\[15\] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0703_ _0422_ _0426_ _0427_ _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__o211a_1
X_0634_ _0395_ _0404_ _0394_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__o21bai_1
X_0565_ pp\[1\]\[3\] pp\[4\]\[3\] VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_13_Left_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0496_ pp\[13\]\[1\] _0288_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1048_ clknet_4_1_0_clk net11 _0267_ VGND VGND VPWR VPWR b1\[0\] sky130_fd_sc_hd__dfrtp_4
XFILLER_0_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0617_ _0391_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__inv_2
X_0548_ pp\[12\]\[3\] _0336_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__and2_1
X_0479_ b2\[0\] a2\[0\] VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__and2_1
XFILLER_14_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0882_ net41 VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__inv_2
X_0951_ clknet_4_12_0_clk _0081_ _0170_ VGND VGND VPWR VPWR g3\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0865_ net48 VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_15_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0934_ clknet_4_13_0_clk net92 _0153_ VGND VGND VPWR VPWR low_sum\[8\] sky130_fd_sc_hd__dfrtp_1
X_0796_ net55 VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_43_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0581_ b2\[0\] a3\[1\] a3\[0\] net35 VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__a22o_1
XFILLER_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0650_ _0411_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__inv_2
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_43_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0779_ net43 VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__inv_2
X_0917_ clknet_4_7_0_clk net63 _0136_ VGND VGND VPWR VPWR final_sum\[7\] sky130_fd_sc_hd__dfrtp_1
X_0848_ net46 VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__inv_2
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold7 final_sum\[2\] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_30_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0633_ _0398_ _0403_ _0397_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_40_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0702_ high_sum\[10\] low_sum\[10\] VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__or2_1
X_0564_ _0330_ _0350_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__and2_1
X_0495_ _0286_ _0289_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__xnor2_1
X_1047_ clknet_4_0_0_clk net10 _0266_ VGND VGND VPWR VPWR b0\[1\] sky130_fd_sc_hd__dfrtp_4
XFILLER_21_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0616_ b3\[0\] a2\[0\] VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__nand2_1
XFILLER_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0547_ _0331_ _0334_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__xor2_1
X_0478_ _0067_ _0279_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0881_ net39 VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__inv_2
X_0950_ clknet_4_7_0_clk _0080_ _0169_ VGND VGND VPWR VPWR g3\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0864_ net46 VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__inv_2
XFILLER_9_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0933_ clknet_4_7_0_clk net98 _0152_ VGND VGND VPWR VPWR low_sum\[7\] sky130_fd_sc_hd__dfrtp_1
X_0795_ net55 VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__inv_2
XFILLER_43_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0580_ _0362_ _0363_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__nor2_1
XFILLER_25_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0916_ clknet_4_7_0_clk net69 _0135_ VGND VGND VPWR VPWR final_sum\[6\] sky130_fd_sc_hd__dfrtp_1
X_0778_ net43 VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__inv_2
X_0847_ net46 VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__inv_2
XFILLER_33_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold8 final_sum\[7\] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_30_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0632_ pp\[11\]\[1\] pp\[14\]\[1\] _0402_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__a21oi_1
X_0563_ _0312_ _0329_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__nand2_1
X_0701_ _0427_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__inv_2
X_0494_ _0286_ _0289_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__nor2_1
X_1046_ clknet_4_2_0_clk net9 _0265_ VGND VGND VPWR VPWR b0\[0\] sky130_fd_sc_hd__dfrtp_4
XFILLER_28_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
X_0615_ _0088_ _0390_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__nor2_1
X_0546_ _0331_ _0334_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__nor2_1
XFILLER_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0477_ b3\[0\] a1\[1\] a1\[0\] net34 VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__a22oi_1
X_1029_ clknet_4_14_0_clk _0098_ _0248_ VGND VGND VPWR VPWR pp\[15\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0529_ _0315_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__or2_1
XFILLER_26_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0880_ net41 VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_18_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0932_ clknet_4_7_0_clk net110 _0151_ VGND VGND VPWR VPWR low_sum\[6\] sky130_fd_sc_hd__dfrtp_1
X_0863_ net46 VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__inv_2
X_0794_ net55 VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_6_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0915_ clknet_4_5_0_clk net70 _0134_ VGND VGND VPWR VPWR final_sum\[5\] sky130_fd_sc_hd__dfrtp_1
X_0777_ net54 VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__inv_2
X_0846_ net46 VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__inv_2
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold9 low_sum\[3\] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_40_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0700_ high_sum\[10\] low_sum\[10\] VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__nand2_1
X_0631_ pp\[11\]\[0\] pp\[14\]\[0\] _0400_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__and3_1
X_0562_ _0344_ _0349_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__xnor2_1
XFILLER_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0493_ pp\[13\]\[1\] _0288_ _0287_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1045_ clknet_4_8_0_clk net8 _0264_ VGND VGND VPWR VPWR a3\[1\] sky130_fd_sc_hd__dfrtp_4
X_0829_ net44 VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__inv_2
XFILLER_12_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0614_ _0385_ _0387_ _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__nor3_1
X_0545_ pp\[9\]\[3\] _0333_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__xnor2_1
X_0476_ net34 a1\[1\] _0066_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__and3_1
X_1028_ clknet_4_11_0_clk _0100_ _0247_ VGND VGND VPWR VPWR pp\[15\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0459_ b0\[0\] a1\[0\] VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__and2_1
X_0528_ pp\[9\]\[1\] _0317_ _0316_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__a21oi_1
XFILLER_25_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0862_ net46 VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__inv_2
X_0931_ clknet_4_5_0_clk net96 _0150_ VGND VGND VPWR VPWR low_sum\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_13_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0793_ net55 VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__inv_2
XFILLER_28_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_5_Left_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0914_ clknet_4_5_0_clk net89 _0133_ VGND VGND VPWR VPWR final_sum\[4\] sky130_fd_sc_hd__dfrtp_1
X_0845_ net46 VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__inv_2
X_0776_ net56 VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__inv_2
XFILLER_15_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0561_ _0346_ _0348_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__nor2_1
X_0492_ pp\[10\]\[1\] pp\[7\]\[1\] VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__xor2_1
X_0630_ pp\[11\]\[0\] pp\[14\]\[0\] VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1044_ clknet_4_8_0_clk net7 _0263_ VGND VGND VPWR VPWR a3\[0\] sky130_fd_sc_hd__dfrtp_4
XFILLER_21_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0828_ net44 VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__inv_2
X_0759_ net56 VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__inv_2
XFILLER_12_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Left_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0613_ _0385_ _0387_ _0389_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__o21a_1
X_0544_ pp\[6\]\[3\] pp\[3\]\[3\] VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__xor2_1
X_0475_ _0066_ net37 net34 VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__and3b_1
X_1027_ clknet_4_14_0_clk _0099_ _0246_ VGND VGND VPWR VPWR pp\[15\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0458_ _0051_ _0275_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__nor2_1
X_0527_ pp\[6\]\[1\] pp\[3\]\[1\] VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__xor2_1
XFILLER_25_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0930_ clknet_4_5_0_clk net112 _0149_ VGND VGND VPWR VPWR low_sum\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_9_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_21_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0792_ net55 VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__inv_2
X_0861_ net48 VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__inv_2
XFILLER_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0913_ clknet_4_5_0_clk net68 _0132_ VGND VGND VPWR VPWR final_sum\[3\] sky130_fd_sc_hd__dfrtp_1
X_0844_ net44 VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__inv_2
X_0775_ net56 VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__inv_2
XFILLER_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0560_ _0335_ _0337_ _0345_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__nor3_1
X_0491_ pp\[10\]\[1\] pp\[7\]\[1\] VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__and2_1
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1043_ clknet_4_2_0_clk net6 _0262_ VGND VGND VPWR VPWR a2\[1\] sky130_fd_sc_hd__dfrtp_4
XFILLER_21_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0827_ net44 VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__inv_2
X_0758_ net56 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__inv_2
X_0689_ _0402_ _0420_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__nor2_1
XFILLER_28_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0612_ pp\[8\]\[3\] _0381_ _0380_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__a21bo_1
X_0543_ pp\[6\]\[3\] pp\[3\]\[3\] VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__and2_1
X_0474_ b3\[0\] a1\[0\] VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__and2_1
X_1026_ clknet_4_11_0_clk _0097_ _0245_ VGND VGND VPWR VPWR pp\[15\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_30_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0526_ pp\[6\]\[1\] pp\[3\]\[1\] VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__and2_1
X_0457_ a0\[0\] net34 b3\[0\] net126 VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__a22oi_1
XFILLER_26_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1009_ clknet_4_8_0_clk _0071_ _0228_ VGND VGND VPWR VPWR pp\[10\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_41_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0509_ _0290_ _0295_ _0302_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__or3b_1
XFILLER_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0791_ net55 VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__inv_2
X_0860_ net47 VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__inv_2
X_0989_ clknet_4_3_0_clk _0059_ _0208_ VGND VGND VPWR VPWR pp\[5\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_42_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0912_ clknet_4_4_0_clk net73 _0131_ VGND VGND VPWR VPWR final_sum\[2\] sky130_fd_sc_hd__dfrtp_1
X_0843_ net47 VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__inv_2
X_0774_ net56 VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_3_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0490_ pp\[13\]\[2\] _0285_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1042_ clknet_4_2_0_clk net5 _0261_ VGND VGND VPWR VPWR a2\[0\] sky130_fd_sc_hd__dfrtp_4
XFILLER_9_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0688_ _0400_ _0401_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__and2b_1
X_0826_ net43 VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__inv_2
X_0757_ net52 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__inv_2
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_28_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0611_ _0387_ _0388_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__and2b_1
X_0542_ pp\[9\]\[2\] _0314_ _0313_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__a21oi_1
X_0473_ _0063_ _0278_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__nor2_1
XFILLER_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1025_ clknet_4_10_0_clk _0085_ _0244_ VGND VGND VPWR VPWR pp\[14\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_0809_ net40 VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__inv_2
XFILLER_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0456_ a0\[1\] net34 _0050_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__and3_1
X_0525_ pp\[9\]\[2\] _0314_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__xnor2_1
XFILLER_26_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1008_ clknet_4_8_0_clk _0073_ _0227_ VGND VGND VPWR VPWR pp\[10\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0508_ _0290_ _0295_ _0302_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__o21ba_1
XFILLER_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0790_ net50 VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__inv_2
X_0988_ clknet_4_4_0_clk _0061_ _0207_ VGND VGND VPWR VPWR pp\[5\]\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_37_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0911_ clknet_4_0_0_clk net78 _0130_ VGND VGND VPWR VPWR final_sum\[1\] sky130_fd_sc_hd__dfrtp_1
X_0842_ net44 VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__inv_2
XFILLER_5_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0773_ net52 VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_3_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1041_ clknet_4_0_0_clk net4 _0260_ VGND VGND VPWR VPWR a1\[1\] sky130_fd_sc_hd__dfrtp_1
X_0825_ net49 VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__inv_2
XFILLER_9_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_31_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0687_ _0358_ _0419_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__and2_1
X_0756_ net52 VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__inv_2
XFILLER_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0610_ _0377_ _0379_ _0386_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__or3b_1
X_0472_ b2\[0\] net37 a1\[0\] net35 VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__a22oi_1
X_0541_ _0328_ _0330_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__xor2_1
X_1024_ clknet_4_10_0_clk _0087_ _0243_ VGND VGND VPWR VPWR pp\[14\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0808_ net40 VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__inv_2
XFILLER_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0739_ net51 VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__inv_2
XFILLER_29_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold60 high_sum\[13\] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_35_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_6_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0524_ pp\[6\]\[2\] pp\[3\]\[2\] VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__xor2_1
X_0455_ _0050_ net34 net38 VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__and3b_1
XFILLER_26_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1007_ clknet_4_8_0_clk _0072_ _0226_ VGND VGND VPWR VPWR pp\[10\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_41_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0507_ _0299_ _0300_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_9_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0987_ clknet_4_3_0_clk _0060_ _0206_ VGND VGND VPWR VPWR pp\[5\]\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_37_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_25_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0910_ clknet_4_1_0_clk net87 _0129_ VGND VGND VPWR VPWR final_sum\[0\] sky130_fd_sc_hd__dfrtp_1
X_0772_ net51 VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__inv_2
X_0841_ net44 VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1040_ clknet_4_2_0_clk net3 _0259_ VGND VGND VPWR VPWR a1\[0\] sky130_fd_sc_hd__dfrtp_2
X_0755_ net52 VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__inv_2
X_0824_ net43 VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_31_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0686_ pp\[1\]\[0\] pp\[4\]\[0\] VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__or2_1
XFILLER_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0540_ _0312_ _0329_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__or2_1
X_0471_ net35 net37 _0062_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__and3_1
X_1023_ clknet_4_10_0_clk _0086_ _0242_ VGND VGND VPWR VPWR pp\[14\]\[1\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_28_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Left_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0807_ net39 VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__inv_2
X_0738_ net51 VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__inv_2
XFILLER_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0669_ g5\[0\] net99 VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__or2_1
XFILLER_20_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold50 g3\[0\] VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 pp\[12\]\[0\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dlygate4sd3_1
X_0454_ a0\[0\] b3\[0\] VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__and2_1
X_0523_ pp\[6\]\[2\] pp\[3\]\[2\] VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__and2_1
X_1006_ clknet_4_8_0_clk _0070_ _0225_ VGND VGND VPWR VPWR pp\[10\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_31_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0506_ _0299_ _0300_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__nor2_1
XFILLER_39_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_42_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0986_ clknet_4_1_0_clk _0058_ _0205_ VGND VGND VPWR VPWR pp\[5\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_27_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Left_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0771_ net51 VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__inv_2
X_0840_ net50 VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__inv_2
XFILLER_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_42_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0969_ clknet_4_0_0_clk _0039_ _0188_ VGND VGND VPWR VPWR pp\[0\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_15_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0685_ _0353_ _0361_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__xnor2_1
X_0823_ net43 VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__inv_2
X_0754_ net51 VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__inv_2
XFILLER_7_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0470_ _0062_ net37 net35 VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__and3b_1
X_1022_ clknet_4_10_0_clk _0084_ _0241_ VGND VGND VPWR VPWR pp\[14\]\[0\] sky130_fd_sc_hd__dfrtp_1
X_0806_ net39 VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__inv_2
X_0737_ net51 VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__inv_2
X_0668_ _0344_ _0348_ _0347_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__o21ai_1
X_0599_ _0375_ _0376_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__xnor2_1
Xhold40 g4\[2\] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold51 _0009_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 pp\[13\]\[0\] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0522_ net120 _0311_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__xnor2_1
X_0453_ _0047_ _0274_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__nor2_1
XFILLER_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1005_ clknet_4_9_0_clk _0035_ _0224_ VGND VGND VPWR VPWR pp\[9\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput30 net30 VGND VGND VPWR VPWR product[6] sky130_fd_sc_hd__buf_2
XFILLER_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0505_ pp\[13\]\[2\] _0285_ _0284_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__a21oi_1
.ends
