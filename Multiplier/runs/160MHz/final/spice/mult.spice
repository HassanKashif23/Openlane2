* NGSPICE file created from mult.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

.subckt mult VGND VPWR a[0] a[1] a[2] a[3] a[4] a[5] a[6] a[7] b[0] b[1] b[2] b[3]
+ b[4] b[5] b[6] b[7] clk product[0] product[10] product[11] product[12] product[13]
+ product[14] product[15] product[1] product[2] product[3] product[4] product[5] product[6]
+ product[7] product[8] product[9] rst
X_432_ _166_ _167_ VGND VGND VPWR VPWR _169_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_15_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_501_ a_low\[1\] net40 VGND VGND VPWR VPWR _231_ sky130_fd_sc_hd__nand2_1
XFILLER_9_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_415_ _145_ _152_ VGND VGND VPWR VPWR _154_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_680_ net47 net41 _353_ VGND VGND VPWR VPWR _373_ sky130_fd_sc_hd__and3_1
XFILLER_18_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_594_ middle_sum\[7\] pp3\[3\] VGND VGND VPWR VPWR _304_ sky130_fd_sc_hd__or2_1
XFILLER_29_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_663_ _337_ _340_ _356_ VGND VGND VPWR VPWR _358_ sky130_fd_sc_hd__or3_1
X_801_ clknet_3_0__leaf_clk _050_ _089_ VGND VGND VPWR VPWR pp1\[5\] sky130_fd_sc_hd__dfrtp_1
X_732_ net63 VGND VGND VPWR VPWR _092_ sky130_fd_sc_hd__inv_2
XFILLER_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput20 net20 VGND VGND VPWR VPWR product[11] sky130_fd_sc_hd__buf_2
X_715_ net64 VGND VGND VPWR VPWR _075_ sky130_fd_sc_hd__inv_2
X_577_ middle_sum\[4\] pp3\[0\] VGND VGND VPWR VPWR _290_ sky130_fd_sc_hd__nand2_1
X_646_ net48 net45 _338_ _339_ VGND VGND VPWR VPWR _342_ sky130_fd_sc_hd__a22o_1
Xoutput31 net31 VGND VGND VPWR VPWR product[7] sky130_fd_sc_hd__buf_2
XFILLER_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_431_ _166_ _167_ VGND VGND VPWR VPWR _168_ sky130_fd_sc_hd__nor2_1
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_15_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_500_ _225_ _227_ _229_ VGND VGND VPWR VPWR _230_ sky130_fd_sc_hd__o21a_1
X_629_ _325_ _326_ VGND VGND VPWR VPWR _012_ sky130_fd_sc_hd__nor2_1
XFILLER_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_414_ _145_ _152_ VGND VGND VPWR VPWR _153_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_28_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Left_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_731_ net60 VGND VGND VPWR VPWR _091_ sky130_fd_sc_hd__inv_2
X_662_ _337_ _340_ _356_ VGND VGND VPWR VPWR _357_ sky130_fd_sc_hd__o21ai_1
X_800_ clknet_3_4__leaf_clk _049_ _088_ VGND VGND VPWR VPWR pp1\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_593_ middle_sum\[7\] pp3\[3\] VGND VGND VPWR VPWR _303_ sky130_fd_sc_hd__nand2_1
XFILLER_19_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_187 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput21 net21 VGND VGND VPWR VPWR product[12] sky130_fd_sc_hd__buf_2
X_714_ net64 VGND VGND VPWR VPWR _074_ sky130_fd_sc_hd__inv_2
Xoutput32 net32 VGND VGND VPWR VPWR product[8] sky130_fd_sc_hd__buf_2
X_645_ net48 net45 _338_ _339_ VGND VGND VPWR VPWR _341_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_18_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_576_ _286_ _288_ _285_ VGND VGND VPWR VPWR _289_ sky130_fd_sc_hd__a21boi_2
XFILLER_22_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_430_ _156_ _160_ _161_ VGND VGND VPWR VPWR _167_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_15_Left_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_559_ _275_ _276_ VGND VGND VPWR VPWR _007_ sky130_fd_sc_hd__xnor2_1
X_628_ net50 net52 net44 net46 VGND VGND VPWR VPWR _326_ sky130_fd_sc_hd__and4_1
XFILLER_3_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Left_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_413_ _150_ _151_ VGND VGND VPWR VPWR _152_ sky130_fd_sc_hd__and2_1
XFILLER_5_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_592_ _300_ _302_ VGND VGND VPWR VPWR _020_ sky130_fd_sc_hd__xnor2_1
X_730_ net61 VGND VGND VPWR VPWR _090_ sky130_fd_sc_hd__inv_2
X_661_ _351_ _354_ VGND VGND VPWR VPWR _356_ sky130_fd_sc_hd__xnor2_1
XFILLER_34_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput22 net22 VGND VGND VPWR VPWR product[13] sky130_fd_sc_hd__buf_2
XFILLER_31_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput33 net33 VGND VGND VPWR VPWR product[9] sky130_fd_sc_hd__buf_2
XFILLER_25_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_713_ net64 VGND VGND VPWR VPWR _073_ sky130_fd_sc_hd__inv_2
X_644_ net48 net45 _338_ _339_ VGND VGND VPWR VPWR _340_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_18_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_575_ _287_ _288_ VGND VGND VPWR VPWR _028_ sky130_fd_sc_hd__xnor2_1
XFILLER_16_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_558_ pp2\[7\] pp1\[7\] VGND VGND VPWR VPWR _276_ sky130_fd_sc_hd__xnor2_1
X_627_ net52 net44 net46 net50 VGND VGND VPWR VPWR _325_ sky130_fd_sc_hd__a22oi_1
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_489_ net53 net42 _217_ VGND VGND VPWR VPWR _219_ sky130_fd_sc_hd__and3_1
XFILLER_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_412_ _125_ _129_ _149_ VGND VGND VPWR VPWR _151_ sky130_fd_sc_hd__or3_1
XFILLER_5_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_591_ _295_ _301_ VGND VGND VPWR VPWR _302_ sky130_fd_sc_hd__and2_1
X_660_ net47 net45 _354_ VGND VGND VPWR VPWR _355_ sky130_fd_sc_hd__and3_1
X_789_ clknet_3_0__leaf_clk _009_ _077_ VGND VGND VPWR VPWR pp0\[1\] sky130_fd_sc_hd__dfrtp_1
Xoutput23 net23 VGND VGND VPWR VPWR product[14] sky130_fd_sc_hd__buf_2
XFILLER_31_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_712_ net65 VGND VGND VPWR VPWR _072_ sky130_fd_sc_hd__inv_2
XFILLER_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_643_ net52 net41 net43 net50 VGND VGND VPWR VPWR _339_ sky130_fd_sc_hd__a22o_1
XFILLER_16_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_574_ _282_ _284_ _281_ VGND VGND VPWR VPWR _288_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_32_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_557_ _272_ _274_ _271_ VGND VGND VPWR VPWR _275_ sky130_fd_sc_hd__o21bai_1
XFILLER_21_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_626_ _319_ _324_ VGND VGND VPWR VPWR _032_ sky130_fd_sc_hd__nor2_1
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_488_ net55 net53 net42 net44 VGND VGND VPWR VPWR _218_ sky130_fd_sc_hd__and4_1
XFILLER_9_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_411_ _125_ _129_ _149_ VGND VGND VPWR VPWR _150_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_609_ net58 net44 VGND VGND VPWR VPWR _313_ sky130_fd_sc_hd__nand2_1
XFILLER_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload0 clknet_3_0__leaf_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__inv_6
XFILLER_1_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_590_ _289_ _293_ _294_ _290_ VGND VGND VPWR VPWR _301_ sky130_fd_sc_hd__o211ai_1
XFILLER_4_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_788_ clknet_3_1__leaf_clk _008_ _076_ VGND VGND VPWR VPWR pp0\[0\] sky130_fd_sc_hd__dfrtp_1
Xoutput24 net24 VGND VGND VPWR VPWR product[15] sky130_fd_sc_hd__buf_2
XFILLER_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_711_ net65 VGND VGND VPWR VPWR _071_ sky130_fd_sc_hd__inv_2
X_642_ net50 net52 net41 net43 VGND VGND VPWR VPWR _338_ sky130_fd_sc_hd__nand4_1
X_573_ _285_ _286_ VGND VGND VPWR VPWR _287_ sky130_fd_sc_hd__nand2_1
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_32_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_625_ _316_ _318_ VGND VGND VPWR VPWR _324_ sky130_fd_sc_hd__nor2_1
X_556_ _273_ _274_ VGND VGND VPWR VPWR _006_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_19_Left_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_487_ net55 net44 VGND VGND VPWR VPWR _217_ sky130_fd_sc_hd__nand2_1
X_410_ _127_ _147_ _146_ VGND VGND VPWR VPWR _149_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_20_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_539_ _259_ _260_ VGND VGND VPWR VPWR _261_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_11_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_608_ _280_ _312_ VGND VGND VPWR VPWR _019_ sky130_fd_sc_hd__and2_1
XFILLER_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_72 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload1 clknet_3_1__leaf_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_787_ clknet_3_7__leaf_clk _007_ _075_ VGND VGND VPWR VPWR middle_sum\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Left_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_641_ net50 net52 net40 net43 VGND VGND VPWR VPWR _337_ sky130_fd_sc_hd__and4_1
X_572_ middle_sum\[3\] pp0\[7\] VGND VGND VPWR VPWR _286_ sky130_fd_sc_hd__or2_1
XFILLER_16_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_710_ net67 VGND VGND VPWR VPWR _070_ sky130_fd_sc_hd__inv_2
Xoutput25 net25 VGND VGND VPWR VPWR product[1] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_32_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_555_ _268_ _270_ _267_ VGND VGND VPWR VPWR _274_ sky130_fd_sc_hd__o21ba_1
X_486_ _215_ _216_ VGND VGND VPWR VPWR _051_ sky130_fd_sc_hd__nor2_1
XFILLER_12_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_624_ _223_ _250_ VGND VGND VPWR VPWR _035_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_20_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_538_ pp2\[3\] pp1\[3\] VGND VGND VPWR VPWR _260_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_20_Left_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_607_ middle_sum\[0\] pp0\[4\] VGND VGND VPWR VPWR _312_ sky130_fd_sc_hd__or2_1
XFILLER_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_469_ _200_ _201_ VGND VGND VPWR VPWR _202_ sky130_fd_sc_hd__nand2_1
Xfanout60 net61 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_4
XFILLER_2_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_73 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload2 clknet_3_2__leaf_clk VGND VGND VPWR VPWR clkload2/X sky130_fd_sc_hd__clkbuf_4
XFILLER_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_786_ clknet_3_7__leaf_clk _006_ _074_ VGND VGND VPWR VPWR middle_sum\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_19_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_640_ net50 net40 VGND VGND VPWR VPWR _336_ sky130_fd_sc_hd__nand2_1
X_571_ middle_sum\[3\] pp0\[7\] VGND VGND VPWR VPWR _285_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput26 net26 VGND VGND VPWR VPWR product[2] sky130_fd_sc_hd__buf_2
XFILLER_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_769_ clknet_3_2__leaf_clk _026_ _057_ VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dfrtp_1
XFILLER_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_554_ _271_ _272_ VGND VGND VPWR VPWR _273_ sky130_fd_sc_hd__nor2_1
X_485_ _213_ _214_ VGND VGND VPWR VPWR _216_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_14_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_623_ _322_ _323_ VGND VGND VPWR VPWR _034_ sky130_fd_sc_hd__xnor2_1
XFILLER_26_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_606_ net72 _310_ VGND VGND VPWR VPWR _025_ sky130_fd_sc_hd__xor2_1
X_399_ _133_ _135_ VGND VGND VPWR VPWR _140_ sky130_fd_sc_hd__xnor2_1
X_537_ pp2\[3\] pp1\[3\] VGND VGND VPWR VPWR _259_ sky130_fd_sc_hd__and2_1
X_468_ net34 a_low\[0\] _188_ _187_ VGND VGND VPWR VPWR _201_ sky130_fd_sc_hd__a31o_1
XFILLER_9_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout50 a_high\[1\] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_2
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_20_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_74 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout61 net17 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_4
XFILLER_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload3 clknet_3_3__leaf_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__clkinv_4
XFILLER_11_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_785_ clknet_3_6__leaf_clk _005_ _073_ VGND VGND VPWR VPWR middle_sum\[5\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_35_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_570_ _283_ _284_ VGND VGND VPWR VPWR _027_ sky130_fd_sc_hd__xnor2_1
Xoutput27 net27 VGND VGND VPWR VPWR product[3] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_26_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_699_ net62 VGND VGND VPWR VPWR _059_ sky130_fd_sc_hd__inv_2
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_768_ clknet_3_2__leaf_clk _019_ _056_ VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dfrtp_1
XFILLER_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_553_ pp2\[6\] pp1\[6\] VGND VGND VPWR VPWR _272_ sky130_fd_sc_hd__nor2_1
XFILLER_16_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_484_ _213_ _214_ VGND VGND VPWR VPWR _215_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_14_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_622_ _319_ _321_ _249_ VGND VGND VPWR VPWR _323_ sky130_fd_sc_hd__a21oi_1
XFILLER_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_605_ _310_ _311_ VGND VGND VPWR VPWR _024_ sky130_fd_sc_hd__and2b_1
X_398_ _124_ _138_ VGND VGND VPWR VPWR _139_ sky130_fd_sc_hd__xnor2_1
XFILLER_27_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_536_ _257_ _258_ VGND VGND VPWR VPWR _002_ sky130_fd_sc_hd__xnor2_1
X_467_ _192_ _198_ VGND VGND VPWR VPWR _200_ sky130_fd_sc_hd__xnor2_1
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout51 a_high\[1\] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_1
XFILLER_13_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_75 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout62 net67 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_4
Xfanout40 b_low\[3\] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_2
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_519_ _237_ _248_ VGND VGND VPWR VPWR _249_ sky130_fd_sc_hd__and2_1
XFILLER_24_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload4 clknet_3_4__leaf_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__clkinv_4
XFILLER_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_784_ clknet_3_6__leaf_clk _004_ _072_ VGND VGND VPWR VPWR middle_sum\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput28 net28 VGND VGND VPWR VPWR product[4] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_26_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_767_ clknet_3_2__leaf_clk net71 _055_ VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dfrtp_1
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_698_ net62 VGND VGND VPWR VPWR _058_ sky130_fd_sc_hd__inv_2
X_552_ pp2\[6\] pp1\[6\] VGND VGND VPWR VPWR _271_ sky130_fd_sc_hd__and2_1
X_483_ _202_ _207_ _208_ VGND VGND VPWR VPWR _214_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_14_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_621_ _235_ _236_ VGND VGND VPWR VPWR _322_ sky130_fd_sc_hd__nor2_1
X_819_ clknet_3_7__leaf_clk _042_ _107_ VGND VGND VPWR VPWR pp3\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_3_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_604_ pp3\[4\] pp3\[5\] _307_ pp3\[6\] VGND VGND VPWR VPWR _311_ sky130_fd_sc_hd__a31o_1
X_397_ _131_ _136_ VGND VGND VPWR VPWR _138_ sky130_fd_sc_hd__xnor2_1
X_466_ _192_ _198_ VGND VGND VPWR VPWR _199_ sky130_fd_sc_hd__nand2b_1
X_535_ pp2\[1\] pp1\[1\] _254_ VGND VGND VPWR VPWR _258_ sky130_fd_sc_hd__a21oi_1
XFILLER_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout52 a_high\[0\] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_2
Xfanout41 b_low\[3\] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_0_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout63 net67 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_4
X_449_ _181_ _182_ net36 net57 VGND VGND VPWR VPWR _183_ sky130_fd_sc_hd__and4bb_1
X_518_ net58 net40 _247_ _245_ VGND VGND VPWR VPWR _248_ sky130_fd_sc_hd__a31o_1
Xclkload5 clknet_3_5__leaf_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__bufinv_16
XFILLER_1_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_783_ clknet_3_6__leaf_clk _003_ _071_ VGND VGND VPWR VPWR middle_sum\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_6_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_27_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Left_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput18 net18 VGND VGND VPWR VPWR product[0] sky130_fd_sc_hd__buf_2
Xoutput29 net29 VGND VGND VPWR VPWR product[5] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_26_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_835_ clknet_3_5__leaf_clk net16 _123_ VGND VGND VPWR VPWR b_high\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_30_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_766_ clknet_3_2__leaf_clk net70 _054_ VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__dfrtp_1
X_697_ net62 VGND VGND VPWR VPWR _057_ sky130_fd_sc_hd__inv_2
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_551_ _269_ _270_ VGND VGND VPWR VPWR _005_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_620_ _319_ _321_ VGND VGND VPWR VPWR _033_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_8_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_818_ clknet_3_5__leaf_clk _046_ _106_ VGND VGND VPWR VPWR pp3\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_16_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_482_ net36 net34 net56 net54 _212_ VGND VGND VPWR VPWR _213_ sky130_fd_sc_hd__a41o_1
XTAP_TAPCELL_ROW_14_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_749_ net59 VGND VGND VPWR VPWR _109_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_3_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_14_Left_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_603_ pp3\[4\] pp3\[5\] pp3\[6\] _307_ VGND VGND VPWR VPWR _310_ sky130_fd_sc_hd__and4_1
XFILLER_32_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_396_ _136_ _131_ VGND VGND VPWR VPWR _137_ sky130_fd_sc_hd__and2b_1
X_534_ _255_ _256_ VGND VGND VPWR VPWR _257_ sky130_fd_sc_hd__nor2_1
X_465_ _196_ _197_ VGND VGND VPWR VPWR _198_ sky130_fd_sc_hd__and2_1
XFILLER_4_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout42 b_low\[2\] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_2
Xfanout64 net66 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_4
Xfanout53 a_low\[3\] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_2
X_448_ net37 net56 net53 net39 VGND VGND VPWR VPWR _182_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_0_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_517_ _242_ _244_ VGND VGND VPWR VPWR _247_ sky130_fd_sc_hd__xnor2_1
Xclkload6 clknet_3_6__leaf_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinv_2
XFILLER_18_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_782_ clknet_3_3__leaf_clk _002_ _070_ VGND VGND VPWR VPWR middle_sum\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_6_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput19 net19 VGND VGND VPWR VPWR product[10] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_26_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_834_ clknet_3_5__leaf_clk net15 _122_ VGND VGND VPWR VPWR b_high\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_30_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_765_ clknet_3_2__leaf_clk net69 _053_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dfrtp_1
X_696_ net62 VGND VGND VPWR VPWR _056_ sky130_fd_sc_hd__inv_2
XFILLER_21_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_817_ clknet_3_7__leaf_clk _045_ _105_ VGND VGND VPWR VPWR pp3\[5\] sky130_fd_sc_hd__dfrtp_1
X_550_ _264_ _266_ _263_ VGND VGND VPWR VPWR _270_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_481_ net34 net54 _211_ VGND VGND VPWR VPWR _212_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_679_ _365_ _372_ VGND VGND VPWR VPWR _039_ sky130_fd_sc_hd__xnor2_1
X_748_ net61 VGND VGND VPWR VPWR _108_ sky130_fd_sc_hd__inv_2
XFILLER_7_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_602_ net73 _308_ VGND VGND VPWR VPWR _023_ sky130_fd_sc_hd__xnor2_1
X_533_ pp2\[2\] pp1\[2\] VGND VGND VPWR VPWR _256_ sky130_fd_sc_hd__nor2_1
X_464_ _181_ _183_ _195_ VGND VGND VPWR VPWR _197_ sky130_fd_sc_hd__or3_1
X_395_ _133_ _134_ _127_ _132_ VGND VGND VPWR VPWR _136_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
Xfanout65 net66 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_4
Xfanout43 b_low\[2\] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_13_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout54 a_low\[3\] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_0_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_516_ net58 net40 VGND VGND VPWR VPWR _246_ sky130_fd_sc_hd__nand2_1
XFILLER_9_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_447_ net39 net37 net56 net53 VGND VGND VPWR VPWR _181_ sky130_fd_sc_hd__and4_1
XFILLER_24_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_781_ clknet_3_2__leaf_clk _001_ _069_ VGND VGND VPWR VPWR middle_sum\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_10_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_833_ clknet_3_5__leaf_clk net14 _121_ VGND VGND VPWR VPWR b_high\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_764_ clknet_3_0__leaf_clk net68 _052_ VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__dfrtp_1
X_695_ net62 VGND VGND VPWR VPWR _055_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_31_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_480_ _173_ _194_ _205_ VGND VGND VPWR VPWR _211_ sky130_fd_sc_hd__o21bai_1
XFILLER_8_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_747_ net66 VGND VGND VPWR VPWR _107_ sky130_fd_sc_hd__inv_2
X_816_ clknet_3_7__leaf_clk _044_ _104_ VGND VGND VPWR VPWR pp3\[4\] sky130_fd_sc_hd__dfrtp_1
X_678_ _357_ _371_ VGND VGND VPWR VPWR _372_ sky130_fd_sc_hd__xnor2_1
X_601_ _308_ _309_ VGND VGND VPWR VPWR _022_ sky130_fd_sc_hd__and2_1
X_394_ _127_ _132_ _134_ VGND VGND VPWR VPWR _135_ sky130_fd_sc_hd__o21ai_1
X_532_ pp2\[2\] pp1\[2\] VGND VGND VPWR VPWR _255_ sky130_fd_sc_hd__and2_1
X_463_ _181_ _183_ _195_ VGND VGND VPWR VPWR _196_ sky130_fd_sc_hd__o21ai_1
XFILLER_4_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout44 b_low\[1\] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_2
Xfanout55 a_low\[2\] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_2
Xfanout66 net67 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__buf_2
XFILLER_13_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_446_ net34 net58 VGND VGND VPWR VPWR _180_ sky130_fd_sc_hd__nand2_1
X_515_ _242_ _244_ VGND VGND VPWR VPWR _245_ sky130_fd_sc_hd__and2b_1
XFILLER_24_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_429_ a_high\[3\] net49 b_high\[2\] net35 _165_ VGND VGND VPWR VPWR _166_ sky130_fd_sc_hd__a41o_1
XFILLER_28_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_780_ clknet_3_2__leaf_clk _000_ _068_ VGND VGND VPWR VPWR middle_sum\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_10_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput1 a[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_29_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_763_ net60 VGND VGND VPWR VPWR _123_ sky130_fd_sc_hd__inv_2
XFILLER_30_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_832_ clknet_3_1__leaf_clk net13 _120_ VGND VGND VPWR VPWR b_high\[0\] sky130_fd_sc_hd__dfrtp_1
X_694_ net62 VGND VGND VPWR VPWR _054_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_31_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_746_ net66 VGND VGND VPWR VPWR _106_ sky130_fd_sc_hd__inv_2
X_815_ clknet_3_7__leaf_clk _043_ _103_ VGND VGND VPWR VPWR pp3\[3\] sky130_fd_sc_hd__dfrtp_1
X_677_ _369_ _370_ VGND VGND VPWR VPWR _371_ sky130_fd_sc_hd__or2_1
XFILLER_7_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_600_ pp3\[4\] _307_ VGND VGND VPWR VPWR _309_ sky130_fd_sc_hd__or2_1
X_393_ b_high\[0\] net49 net51 net38 VGND VGND VPWR VPWR _134_ sky130_fd_sc_hd__a22o_1
XFILLER_27_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_462_ _173_ _194_ _193_ VGND VGND VPWR VPWR _195_ sky130_fd_sc_hd__o21a_1
X_531_ _253_ _254_ VGND VGND VPWR VPWR _001_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_10_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Left_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_729_ net61 VGND VGND VPWR VPWR _089_ sky130_fd_sc_hd__inv_2
Xfanout34 b_high\[3\] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_2
Xfanout45 b_low\[1\] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_13_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout56 a_low\[2\] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_2
XFILLER_1_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_514_ _227_ _243_ VGND VGND VPWR VPWR _244_ sky130_fd_sc_hd__nor2_1
Xfanout67 net17 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__buf_2
X_445_ _178_ _179_ VGND VGND VPWR VPWR _018_ sky130_fd_sc_hd__nor2_1
XFILLER_24_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_3_Left_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_428_ a_high\[3\] net35 _164_ VGND VGND VPWR VPWR _165_ sky130_fd_sc_hd__a21oi_1
Xinput2 a[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
XFILLER_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_762_ net60 VGND VGND VPWR VPWR _122_ sky130_fd_sc_hd__inv_2
X_693_ net63 VGND VGND VPWR VPWR _053_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_6_Left_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_831_ clknet_3_1__leaf_clk net12 _119_ VGND VGND VPWR VPWR b_low\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_30_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_32_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_745_ net64 VGND VGND VPWR VPWR _105_ sky130_fd_sc_hd__inv_2
XFILLER_32_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_814_ clknet_3_7__leaf_clk _015_ _102_ VGND VGND VPWR VPWR pp3\[2\] sky130_fd_sc_hd__dfrtp_1
X_676_ _352_ _355_ _368_ VGND VGND VPWR VPWR _370_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_22_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_392_ b_high\[2\] net52 VGND VGND VPWR VPWR _133_ sky130_fd_sc_hd__and2_1
XFILLER_27_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_461_ net36 net54 VGND VGND VPWR VPWR _194_ sky130_fd_sc_hd__nand2_1
X_530_ pp2\[0\] pp1\[0\] _251_ VGND VGND VPWR VPWR _254_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_10_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_659_ _336_ _353_ _352_ VGND VGND VPWR VPWR _354_ sky130_fd_sc_hd__a21oi_1
X_728_ net64 VGND VGND VPWR VPWR _088_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_4_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout35 b_high\[3\] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_14_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout57 a_low\[1\] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_2
Xfanout46 b_low\[0\] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_35_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_444_ _171_ _177_ VGND VGND VPWR VPWR _179_ sky130_fd_sc_hd__nor2_1
X_513_ net57 net42 _225_ _226_ VGND VGND VPWR VPWR _243_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_24_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_427_ _126_ _148_ _158_ VGND VGND VPWR VPWR _164_ sky130_fd_sc_hd__a21o_1
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_1_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput3 a[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XFILLER_33_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_761_ net60 VGND VGND VPWR VPWR _121_ sky130_fd_sc_hd__inv_2
XFILLER_24_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_830_ clknet_3_1__leaf_clk net11 _118_ VGND VGND VPWR VPWR b_low\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_30_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_692_ _142_ _381_ VGND VGND VPWR VPWR _015_ sky130_fd_sc_hd__nor2_1
XFILLER_21_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_744_ net64 VGND VGND VPWR VPWR _104_ sky130_fd_sc_hd__inv_2
X_813_ clknet_3_6__leaf_clk _014_ _101_ VGND VGND VPWR VPWR pp3\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_22_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_675_ _352_ _355_ _368_ VGND VGND VPWR VPWR _369_ sky130_fd_sc_hd__o21a_1
XFILLER_16_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_391_ net39 net51 VGND VGND VPWR VPWR _132_ sky130_fd_sc_hd__nand2_1
X_460_ net36 net56 net54 net37 VGND VGND VPWR VPWR _193_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_10_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_589_ _298_ _299_ VGND VGND VPWR VPWR _300_ sky130_fd_sc_hd__nand2b_1
X_658_ net48 net43 VGND VGND VPWR VPWR _353_ sky130_fd_sc_hd__nand2_1
X_727_ net64 VGND VGND VPWR VPWR _087_ sky130_fd_sc_hd__inv_2
XFILLER_4_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout47 a_high\[3\] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_2
Xfanout36 b_high\[2\] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_2
XFILLER_13_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout58 a_low\[0\] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__buf_2
X_443_ _171_ _177_ VGND VGND VPWR VPWR _178_ sky130_fd_sc_hd__and2_1
X_512_ _239_ _240_ _217_ _238_ VGND VGND VPWR VPWR _242_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_426_ _162_ _163_ VGND VGND VPWR VPWR _045_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_1_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput4 a[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
X_409_ _147_ VGND VGND VPWR VPWR _148_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_34_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_691_ _140_ _141_ VGND VGND VPWR VPWR _381_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_25_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_760_ net59 VGND VGND VPWR VPWR _120_ sky130_fd_sc_hd__inv_2
XFILLER_32_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_743_ net64 VGND VGND VPWR VPWR _103_ sky130_fd_sc_hd__inv_2
X_812_ clknet_3_6__leaf_clk _013_ _100_ VGND VGND VPWR VPWR pp3\[0\] sky130_fd_sc_hd__dfrtp_1
X_674_ _366_ _367_ VGND VGND VPWR VPWR _368_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_22_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_390_ _129_ _130_ VGND VGND VPWR VPWR _131_ sky130_fd_sc_hd__nor2_1
XFILLER_27_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_588_ middle_sum\[6\] pp3\[2\] VGND VGND VPWR VPWR _299_ sky130_fd_sc_hd__or2_1
X_657_ net48 net50 net41 net43 VGND VGND VPWR VPWR _352_ sky130_fd_sc_hd__and4_1
X_726_ net63 VGND VGND VPWR VPWR _086_ sky130_fd_sc_hd__inv_2
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout37 b_high\[1\] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_2
Xfanout48 a_high\[2\] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_2
Xfanout59 net61 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_4_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_442_ _172_ _176_ VGND VGND VPWR VPWR _177_ sky130_fd_sc_hd__xnor2_1
XFILLER_1_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_511_ _217_ _238_ _240_ VGND VGND VPWR VPWR _241_ sky130_fd_sc_hd__o21ai_1
X_709_ net62 VGND VGND VPWR VPWR _069_ sky130_fd_sc_hd__inv_2
X_425_ _143_ _157_ _156_ VGND VGND VPWR VPWR _163_ sky130_fd_sc_hd__a21bo_1
Xinput5 a[4] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
XFILLER_35_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_408_ net47 b_high\[2\] VGND VGND VPWR VPWR _147_ sky130_fd_sc_hd__nand2_1
XFILLER_18_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_690_ _132_ _380_ _141_ VGND VGND VPWR VPWR _014_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_25_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_811_ clknet_3_5__leaf_clk _041_ _099_ VGND VGND VPWR VPWR pp2\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_742_ net66 VGND VGND VPWR VPWR _102_ sky130_fd_sc_hd__inv_2
X_673_ net47 net48 net41 net43 VGND VGND VPWR VPWR _367_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_13_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_587_ middle_sum\[6\] pp3\[2\] VGND VGND VPWR VPWR _298_ sky130_fd_sc_hd__and2_1
X_656_ net47 net45 VGND VGND VPWR VPWR _351_ sky130_fd_sc_hd__nand2_1
X_725_ net63 VGND VGND VPWR VPWR _085_ sky130_fd_sc_hd__inv_2
XFILLER_4_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout49 a_high\[2\] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_2
Xfanout38 b_high\[1\] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dlymetal6s2s_1
X_441_ _174_ _175_ VGND VGND VPWR VPWR _176_ sky130_fd_sc_hd__and2b_1
X_510_ a_low\[1\] net44 net46 net55 VGND VGND VPWR VPWR _240_ sky130_fd_sc_hd__a22o_1
X_639_ net47 b_low\[0\] VGND VGND VPWR VPWR _335_ sky130_fd_sc_hd__nand2_1
X_708_ net62 VGND VGND VPWR VPWR _068_ sky130_fd_sc_hd__inv_2
XFILLER_24_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_424_ _160_ _161_ VGND VGND VPWR VPWR _162_ sky130_fd_sc_hd__or2_1
XFILLER_30_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Left_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput6 a[5] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
XFILLER_19_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_407_ a_high\[3\] net38 net49 b_high\[2\] VGND VGND VPWR VPWR _146_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_28_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Left_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_810_ clknet_3_4__leaf_clk _040_ _098_ VGND VGND VPWR VPWR pp2\[6\] sky130_fd_sc_hd__dfrtp_1
X_741_ net64 VGND VGND VPWR VPWR _101_ sky130_fd_sc_hd__inv_2
X_672_ net48 net41 net43 net47 VGND VGND VPWR VPWR _366_ sky130_fd_sc_hd__a22o_1
XFILLER_11_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_724_ net63 VGND VGND VPWR VPWR _084_ sky130_fd_sc_hd__inv_2
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_586_ _296_ _297_ VGND VGND VPWR VPWR _030_ sky130_fd_sc_hd__xnor2_1
X_655_ _349_ _350_ VGND VGND VPWR VPWR _037_ sky130_fd_sc_hd__and2_1
XFILLER_16_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_440_ net37 net57 net56 net39 VGND VGND VPWR VPWR _175_ sky130_fd_sc_hd__a22o_1
Xfanout39 b_high\[0\] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_2
X_707_ net66 VGND VGND VPWR VPWR _067_ sky130_fd_sc_hd__inv_2
X_638_ _333_ _334_ VGND VGND VPWR VPWR _036_ sky130_fd_sc_hd__and2_1
XFILLER_0_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_569_ middle_sum\[0\] pp0\[4\] _279_ _278_ VGND VGND VPWR VPWR _284_ sky130_fd_sc_hd__a31o_1
XFILLER_9_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_423_ _150_ _153_ _158_ _159_ VGND VGND VPWR VPWR _161_ sky130_fd_sc_hd__a211oi_1
XFILLER_14_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput7 a[6] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
XFILLER_35_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_406_ net51 net34 VGND VGND VPWR VPWR _145_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput10 b[1] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
XFILLER_32_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_740_ net65 VGND VGND VPWR VPWR _100_ sky130_fd_sc_hd__inv_2
X_671_ _363_ _364_ _361_ VGND VGND VPWR VPWR _365_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_7_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_585_ _289_ _293_ _290_ VGND VGND VPWR VPWR _297_ sky130_fd_sc_hd__o21a_1
X_654_ _347_ _348_ _333_ VGND VGND VPWR VPWR _350_ sky130_fd_sc_hd__o21ai_1
XFILLER_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_723_ net67 VGND VGND VPWR VPWR _083_ sky130_fd_sc_hd__inv_2
XFILLER_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_706_ net65 VGND VGND VPWR VPWR _066_ sky130_fd_sc_hd__inv_2
X_637_ _326_ _332_ VGND VGND VPWR VPWR _334_ sky130_fd_sc_hd__or2_1
XFILLER_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_568_ _281_ _282_ VGND VGND VPWR VPWR _283_ sky130_fd_sc_hd__nand2_1
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_499_ _218_ _228_ VGND VGND VPWR VPWR _229_ sky130_fd_sc_hd__nor2_1
X_422_ _158_ _159_ _150_ _153_ VGND VGND VPWR VPWR _160_ sky130_fd_sc_hd__o211a_1
Xinput8 a[7] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_35_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_405_ _143_ _144_ VGND VGND VPWR VPWR _043_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_28_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput11 b[2] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_670_ _362_ _364_ VGND VGND VPWR VPWR _038_ sky130_fd_sc_hd__xnor2_1
XFILLER_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_799_ clknet_3_6__leaf_clk _048_ _087_ VGND VGND VPWR VPWR pp1\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_14_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_584_ _294_ _295_ VGND VGND VPWR VPWR _296_ sky130_fd_sc_hd__and2_1
X_653_ _333_ _347_ _348_ VGND VGND VPWR VPWR _349_ sky130_fd_sc_hd__or3_1
XFILLER_17_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_722_ net67 VGND VGND VPWR VPWR _082_ sky130_fd_sc_hd__inv_2
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_705_ net65 VGND VGND VPWR VPWR _065_ sky130_fd_sc_hd__inv_2
XFILLER_28_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_636_ _326_ _332_ VGND VGND VPWR VPWR _333_ sky130_fd_sc_hd__nand2_1
X_567_ middle_sum\[2\] pp0\[6\] VGND VGND VPWR VPWR _282_ sky130_fd_sc_hd__or2_1
X_498_ net55 net42 net44 net53 VGND VGND VPWR VPWR _228_ sky130_fd_sc_hd__a22oi_1
X_421_ net49 net35 _126_ _147_ VGND VGND VPWR VPWR _159_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_14_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput9 b[0] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
X_619_ _249_ _320_ VGND VGND VPWR VPWR _321_ sky130_fd_sc_hd__nor2_1
XFILLER_35_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_404_ _139_ _142_ VGND VGND VPWR VPWR _144_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_28_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput12 b[3] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_798_ clknet_3_3__leaf_clk _018_ _086_ VGND VGND VPWR VPWR pp1\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_7_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_583_ middle_sum\[5\] pp3\[1\] VGND VGND VPWR VPWR _295_ sky130_fd_sc_hd__or2_1
X_652_ _345_ _346_ _330_ VGND VGND VPWR VPWR _348_ sky130_fd_sc_hd__a21oi_1
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_721_ net62 VGND VGND VPWR VPWR _081_ sky130_fd_sc_hd__inv_2
Xhold1 pp0\[0\] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_704_ net65 VGND VGND VPWR VPWR _064_ sky130_fd_sc_hd__inv_2
XFILLER_28_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_635_ _330_ _331_ VGND VGND VPWR VPWR _332_ sky130_fd_sc_hd__nor2_1
X_566_ middle_sum\[2\] pp0\[6\] VGND VGND VPWR VPWR _281_ sky130_fd_sc_hd__nand2_1
XFILLER_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_497_ _225_ _226_ net57 net42 VGND VGND VPWR VPWR _227_ sky130_fd_sc_hd__and4bb_1
XPHY_EDGE_ROW_17_Left_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_420_ net49 net35 _127_ _148_ VGND VGND VPWR VPWR _158_ sky130_fd_sc_hd__and4_1
XFILLER_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_549_ _267_ _268_ VGND VGND VPWR VPWR _269_ sky130_fd_sc_hd__nor2_1
X_618_ _237_ _248_ VGND VGND VPWR VPWR _320_ sky130_fd_sc_hd__nor2_1
X_403_ _139_ _142_ VGND VGND VPWR VPWR _143_ sky130_fd_sc_hd__and2_1
XFILLER_26_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_2_Left_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput13 b[4] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_5_Left_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_797_ clknet_3_0__leaf_clk _017_ _085_ VGND VGND VPWR VPWR pp1\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_31_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_582_ middle_sum\[5\] pp3\[1\] VGND VGND VPWR VPWR _294_ sky130_fd_sc_hd__nand2_1
X_651_ _330_ _345_ _346_ VGND VGND VPWR VPWR _347_ sky130_fd_sc_hd__and3_1
X_720_ net62 VGND VGND VPWR VPWR _080_ sky130_fd_sc_hd__inv_2
Xhold2 pp0\[1\] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dlygate4sd3_1
X_703_ net65 VGND VGND VPWR VPWR _063_ sky130_fd_sc_hd__inv_2
X_634_ net48 net46 _328_ _329_ VGND VGND VPWR VPWR _331_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_496_ net55 net44 net46 net53 VGND VGND VPWR VPWR _226_ sky130_fd_sc_hd__a22oi_1
X_565_ _279_ _280_ VGND VGND VPWR VPWR _026_ sky130_fd_sc_hd__xnor2_1
XFILLER_10_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_34_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_548_ pp2\[5\] pp1\[5\] VGND VGND VPWR VPWR _268_ sky130_fd_sc_hd__nor2_1
X_479_ _209_ _210_ VGND VGND VPWR VPWR _050_ sky130_fd_sc_hd__xnor2_1
X_617_ _316_ _318_ VGND VGND VPWR VPWR _319_ sky130_fd_sc_hd__and2_1
XFILLER_35_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_402_ _140_ _141_ VGND VGND VPWR VPWR _142_ sky130_fd_sc_hd__and2_1
XFILLER_25_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput14 b[5] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
XFILLER_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_796_ clknet_3_2__leaf_clk _016_ _084_ VGND VGND VPWR VPWR pp1\[0\] sky130_fd_sc_hd__dfrtp_1
X_650_ _343_ _344_ _335_ VGND VGND VPWR VPWR _346_ sky130_fd_sc_hd__a21bo_1
XFILLER_4_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_779_ clknet_3_7__leaf_clk _025_ _067_ VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dfrtp_1
X_581_ _289_ _292_ VGND VGND VPWR VPWR _029_ sky130_fd_sc_hd__xnor2_1
Xhold3 pp0\[2\] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_702_ net65 VGND VGND VPWR VPWR _062_ sky130_fd_sc_hd__inv_2
X_633_ _329_ net46 net48 _327_ VGND VGND VPWR VPWR _330_ sky130_fd_sc_hd__and4b_1
X_495_ net55 net53 net44 net46 VGND VGND VPWR VPWR _225_ sky130_fd_sc_hd__and4_1
X_564_ middle_sum\[0\] pp0\[4\] VGND VGND VPWR VPWR _280_ sky130_fd_sc_hd__nand2_1
XFILLER_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_547_ pp2\[5\] pp1\[5\] VGND VGND VPWR VPWR _267_ sky130_fd_sc_hd__and2_1
X_478_ _190_ _203_ _202_ VGND VGND VPWR VPWR _210_ sky130_fd_sc_hd__a21bo_1
X_616_ _246_ _247_ VGND VGND VPWR VPWR _318_ sky130_fd_sc_hd__xnor2_1
XFILLER_35_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_401_ net38 net51 _013_ VGND VGND VPWR VPWR _141_ sky130_fd_sc_hd__and3_1
XFILLER_32_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput15 b[6] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_19_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_795_ clknet_3_3__leaf_clk _031_ _083_ VGND VGND VPWR VPWR pp0\[7\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_35_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_580_ _292_ VGND VGND VPWR VPWR _293_ sky130_fd_sc_hd__inv_2
XFILLER_16_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold4 pp0\[3\] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_778_ clknet_3_7__leaf_clk _024_ _066_ VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dfrtp_1
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_701_ net65 VGND VGND VPWR VPWR _061_ sky130_fd_sc_hd__inv_2
X_632_ net50 net52 net42 net45 VGND VGND VPWR VPWR _329_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_563_ middle_sum\[1\] pp0\[5\] VGND VGND VPWR VPWR _279_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_494_ net53 net42 _217_ net40 net55 VGND VGND VPWR VPWR _224_ sky130_fd_sc_hd__a32o_1
X_546_ _265_ _266_ VGND VGND VPWR VPWR _004_ sky130_fd_sc_hd__xnor2_1
X_477_ _207_ _208_ VGND VGND VPWR VPWR _209_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_1_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_615_ _316_ _317_ VGND VGND VPWR VPWR _010_ sky130_fd_sc_hd__nor2_1
XFILLER_35_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_400_ b_high\[0\] a_high\[0\] VGND VGND VPWR VPWR _013_ sky130_fd_sc_hd__and2_1
XFILLER_17_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_529_ _251_ _252_ VGND VGND VPWR VPWR _253_ sky130_fd_sc_hd__and2b_1
XFILLER_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput16 b[7] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_794_ clknet_3_3__leaf_clk _035_ _082_ VGND VGND VPWR VPWR pp0\[6\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_12_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Left_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_777_ clknet_3_7__leaf_clk _023_ _065_ VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dfrtp_1
Xhold5 pp3\[7\] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dlygate4sd3_1
X_700_ net65 VGND VGND VPWR VPWR _060_ sky130_fd_sc_hd__inv_2
XFILLER_0_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_631_ _327_ VGND VGND VPWR VPWR _328_ sky130_fd_sc_hd__inv_2
X_829_ clknet_3_1__leaf_clk net10 _117_ VGND VGND VPWR VPWR b_low\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_562_ middle_sum\[1\] pp0\[5\] VGND VGND VPWR VPWR _278_ sky130_fd_sc_hd__and2_1
X_493_ _221_ _222_ VGND VGND VPWR VPWR _223_ sky130_fd_sc_hd__nand2b_1
XFILLER_8_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_545_ _260_ _262_ _259_ VGND VGND VPWR VPWR _266_ sky130_fd_sc_hd__o21ba_1
X_476_ _196_ _199_ _205_ _206_ VGND VGND VPWR VPWR _208_ sky130_fd_sc_hd__a211oi_1
XFILLER_14_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_614_ _314_ _315_ VGND VGND VPWR VPWR _317_ sky130_fd_sc_hd__nor2_1
XFILLER_35_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_22_Left_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_459_ net34 net57 VGND VGND VPWR VPWR _192_ sky130_fd_sc_hd__nand2_1
X_528_ pp2\[0\] pp1\[0\] VGND VGND VPWR VPWR _252_ sky130_fd_sc_hd__nand2_1
XFILLER_23_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput17 rst VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
XFILLER_20_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_793_ clknet_3_2__leaf_clk _034_ _081_ VGND VGND VPWR VPWR pp0\[5\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_35_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold6 pp3\[5\] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dlygate4sd3_1
X_776_ clknet_3_7__leaf_clk _022_ _064_ VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dfrtp_1
XFILLER_30_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_630_ net52 net42 net45 net50 VGND VGND VPWR VPWR _327_ sky130_fd_sc_hd__a22o_1
XFILLER_12_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_561_ _252_ _277_ VGND VGND VPWR VPWR _000_ sky130_fd_sc_hd__and2_1
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_492_ net53 net40 _218_ VGND VGND VPWR VPWR _222_ sky130_fd_sc_hd__a21o_1
X_828_ clknet_3_1__leaf_clk net9 _116_ VGND VGND VPWR VPWR b_low\[0\] sky130_fd_sc_hd__dfrtp_1
X_759_ net59 VGND VGND VPWR VPWR _119_ sky130_fd_sc_hd__inv_2
XFILLER_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_613_ _314_ _315_ VGND VGND VPWR VPWR _316_ sky130_fd_sc_hd__and2_1
XFILLER_35_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_544_ _263_ _264_ VGND VGND VPWR VPWR _265_ sky130_fd_sc_hd__nor2_1
X_475_ _205_ _206_ _196_ _199_ VGND VGND VPWR VPWR _207_ sky130_fd_sc_hd__o211a_1
XFILLER_25_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_389_ net36 net50 _125_ _128_ VGND VGND VPWR VPWR _130_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_27_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_458_ _190_ _191_ VGND VGND VPWR VPWR _048_ sky130_fd_sc_hd__nor2_1
X_527_ pp2\[1\] pp1\[1\] VGND VGND VPWR VPWR _251_ sky130_fd_sc_hd__xor2_1
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_792_ clknet_3_2__leaf_clk _033_ _080_ VGND VGND VPWR VPWR pp0\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_35_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_775_ clknet_3_7__leaf_clk _021_ _063_ VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dfrtp_1
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold7 a_low\[0\] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_560_ pp2\[0\] pp1\[0\] VGND VGND VPWR VPWR _277_ sky130_fd_sc_hd__or2_1
X_491_ net55 net53 net40 net42 VGND VGND VPWR VPWR _221_ sky130_fd_sc_hd__and4_1
X_827_ clknet_3_5__leaf_clk net8 _115_ VGND VGND VPWR VPWR a_high\[3\] sky130_fd_sc_hd__dfrtp_1
X_689_ net38 a_high\[0\] VGND VGND VPWR VPWR _380_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_758_ net59 VGND VGND VPWR VPWR _118_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_543_ pp2\[4\] pp1\[4\] VGND VGND VPWR VPWR _264_ sky130_fd_sc_hd__nor2_1
X_474_ net34 net56 _204_ VGND VGND VPWR VPWR _206_ sky130_fd_sc_hd__a21oi_1
X_612_ _239_ _241_ VGND VGND VPWR VPWR _315_ sky130_fd_sc_hd__xnor2_1
XFILLER_35_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_526_ net52 net46 VGND VGND VPWR VPWR _011_ sky130_fd_sc_hd__and2_1
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_388_ _125_ _128_ net36 net51 VGND VGND VPWR VPWR _129_ sky130_fd_sc_hd__and4bb_1
XFILLER_23_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_457_ _178_ _189_ VGND VGND VPWR VPWR _191_ sky130_fd_sc_hd__nor2_1
XFILLER_22_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_509_ net58 net42 VGND VGND VPWR VPWR _239_ sky130_fd_sc_hd__and2_1
XFILLER_9_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_791_ clknet_3_2__leaf_clk _032_ _079_ VGND VGND VPWR VPWR pp0\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_774_ clknet_3_7__leaf_clk _020_ _062_ VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dfrtp_1
XFILLER_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_490_ net55 net40 _219_ VGND VGND VPWR VPWR _220_ sky130_fd_sc_hd__nand3_1
X_826_ clknet_3_5__leaf_clk net7 _114_ VGND VGND VPWR VPWR a_high\[2\] sky130_fd_sc_hd__dfrtp_1
X_688_ _367_ _374_ _378_ VGND VGND VPWR VPWR _041_ sky130_fd_sc_hd__nand3_1
X_757_ net59 VGND VGND VPWR VPWR _117_ sky130_fd_sc_hd__inv_2
X_542_ pp2\[4\] pp1\[4\] VGND VGND VPWR VPWR _263_ sky130_fd_sc_hd__and2_1
X_473_ net34 net56 _204_ VGND VGND VPWR VPWR _205_ sky130_fd_sc_hd__and3_1
X_611_ _238_ _313_ _314_ VGND VGND VPWR VPWR _009_ sky130_fd_sc_hd__a21oi_1
XFILLER_35_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_809_ clknet_3_4__leaf_clk _039_ _097_ VGND VGND VPWR VPWR pp2\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_26_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_387_ net47 net39 net38 net49 VGND VGND VPWR VPWR _128_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_18_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_456_ _178_ _189_ VGND VGND VPWR VPWR _190_ sky130_fd_sc_hd__and2_1
X_525_ net39 net74 VGND VGND VPWR VPWR _016_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_2_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_439_ net39 net37 net57 net56 VGND VGND VPWR VPWR _174_ sky130_fd_sc_hd__and4_1
X_508_ net57 net46 VGND VGND VPWR VPWR _238_ sky130_fd_sc_hd__nand2_1
XFILLER_22_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_790_ clknet_3_2__leaf_clk _010_ _078_ VGND VGND VPWR VPWR pp0\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_773_ clknet_3_6__leaf_clk _030_ _061_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_13_Left_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_825_ clknet_3_5__leaf_clk net6 _113_ VGND VGND VPWR VPWR a_high\[1\] sky130_fd_sc_hd__dfrtp_1
X_687_ _378_ _379_ VGND VGND VPWR VPWR _040_ sky130_fd_sc_hd__and2_1
X_756_ net59 VGND VGND VPWR VPWR _116_ sky130_fd_sc_hd__inv_2
XFILLER_14_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_541_ _261_ _262_ VGND VGND VPWR VPWR _003_ sky130_fd_sc_hd__xnor2_1
X_472_ net36 net54 _173_ VGND VGND VPWR VPWR _204_ sky130_fd_sc_hd__and3_1
X_610_ a_low\[1\] net44 _008_ VGND VGND VPWR VPWR _314_ sky130_fd_sc_hd__and3_1
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_739_ net60 VGND VGND VPWR VPWR _099_ sky130_fd_sc_hd__inv_2
X_808_ clknet_3_4__leaf_clk _038_ _096_ VGND VGND VPWR VPWR pp2\[4\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_16_Left_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_386_ net38 net49 VGND VGND VPWR VPWR _127_ sky130_fd_sc_hd__nand2_1
X_455_ _180_ _188_ VGND VGND VPWR VPWR _189_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_2_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_524_ net58 net46 VGND VGND VPWR VPWR _008_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_18_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_1_Left_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_438_ net37 net55 VGND VGND VPWR VPWR _173_ sky130_fd_sc_hd__nand2_1
XFILLER_11_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_507_ _231_ _233_ VGND VGND VPWR VPWR _237_ sky130_fd_sc_hd__xnor2_1
XFILLER_12_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_772_ clknet_3_6__leaf_clk _029_ _060_ VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_4_Left_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_755_ net60 VGND VGND VPWR VPWR _115_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_30_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_824_ clknet_3_5__leaf_clk net5 _112_ VGND VGND VPWR VPWR a_high\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_12_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_686_ _376_ _377_ VGND VGND VPWR VPWR _379_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_5_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_540_ _256_ _258_ _255_ VGND VGND VPWR VPWR _262_ sky130_fd_sc_hd__o21ba_1
X_471_ _190_ _203_ VGND VGND VPWR VPWR _049_ sky130_fd_sc_hd__xor2_1
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_738_ net60 VGND VGND VPWR VPWR _098_ sky130_fd_sc_hd__inv_2
X_807_ clknet_3_4__leaf_clk _037_ _095_ VGND VGND VPWR VPWR pp2\[3\] sky130_fd_sc_hd__dfrtp_1
X_669_ _333_ _348_ _347_ VGND VGND VPWR VPWR _364_ sky130_fd_sc_hd__o21ba_1
XFILLER_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_385_ net37 net49 VGND VGND VPWR VPWR _126_ sky130_fd_sc_hd__and2_1
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_523_ net34 net54 _211_ _215_ VGND VGND VPWR VPWR _047_ sky130_fd_sc_hd__a31o_1
X_454_ _185_ _186_ VGND VGND VPWR VPWR _188_ sky130_fd_sc_hd__xnor2_1
XFILLER_1_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_437_ net36 net58 VGND VGND VPWR VPWR _172_ sky130_fd_sc_hd__nand2_1
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_506_ _220_ _224_ _230_ _234_ VGND VGND VPWR VPWR _236_ sky130_fd_sc_hd__a211oi_1
XFILLER_9_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_771_ clknet_3_6__leaf_clk _028_ _059_ VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__dfrtp_1
XFILLER_31_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_823_ clknet_3_0__leaf_clk net4 _111_ VGND VGND VPWR VPWR a_low\[3\] sky130_fd_sc_hd__dfrtp_1
X_754_ net60 VGND VGND VPWR VPWR _114_ sky130_fd_sc_hd__inv_2
X_685_ _376_ _377_ VGND VGND VPWR VPWR _378_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_5_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_599_ pp3\[4\] _307_ VGND VGND VPWR VPWR _308_ sky130_fd_sc_hd__nand2_1
X_737_ net61 VGND VGND VPWR VPWR _097_ sky130_fd_sc_hd__inv_2
X_668_ _362_ VGND VGND VPWR VPWR _363_ sky130_fd_sc_hd__inv_2
XFILLER_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_806_ clknet_3_6__leaf_clk _036_ _094_ VGND VGND VPWR VPWR pp2\[2\] sky130_fd_sc_hd__dfrtp_1
X_470_ _200_ _201_ VGND VGND VPWR VPWR _203_ sky130_fd_sc_hd__xor2_1
XFILLER_25_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_522_ net47 net35 _164_ _168_ VGND VGND VPWR VPWR _042_ sky130_fd_sc_hd__a31o_1
X_384_ net47 net39 net37 net48 VGND VGND VPWR VPWR _125_ sky130_fd_sc_hd__and4_1
XFILLER_17_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_453_ _186_ _185_ VGND VGND VPWR VPWR _187_ sky130_fd_sc_hd__and2b_1
XFILLER_9_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_436_ _170_ _171_ VGND VGND VPWR VPWR _017_ sky130_fd_sc_hd__nor2_1
X_505_ _230_ _234_ _220_ _224_ VGND VGND VPWR VPWR _235_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_21_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_419_ _143_ _157_ VGND VGND VPWR VPWR _044_ sky130_fd_sc_hd__xor2_1
XFILLER_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_770_ clknet_3_3__leaf_clk _027_ _058_ VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_753_ net60 VGND VGND VPWR VPWR _113_ sky130_fd_sc_hd__inv_2
X_684_ _357_ _361_ _364_ _371_ VGND VGND VPWR VPWR _377_ sky130_fd_sc_hd__a31o_1
XFILLER_18_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_822_ clknet_3_0__leaf_clk net3 _110_ VGND VGND VPWR VPWR a_low\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_736_ net61 VGND VGND VPWR VPWR _096_ sky130_fd_sc_hd__inv_2
X_805_ clknet_3_3__leaf_clk _012_ _093_ VGND VGND VPWR VPWR pp2\[1\] sky130_fd_sc_hd__dfrtp_1
X_598_ _304_ _306_ _303_ VGND VGND VPWR VPWR _307_ sky130_fd_sc_hd__a21bo_1
X_667_ _359_ _360_ VGND VGND VPWR VPWR _362_ sky130_fd_sc_hd__xnor2_1
XFILLER_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_383_ net52 net34 VGND VGND VPWR VPWR _124_ sky130_fd_sc_hd__nand2_1
X_452_ net36 net58 _175_ _174_ VGND VGND VPWR VPWR _186_ sky130_fd_sc_hd__a31oi_1
X_521_ _222_ _250_ _221_ VGND VGND VPWR VPWR _031_ sky130_fd_sc_hd__a21o_1
XFILLER_15_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_719_ net63 VGND VGND VPWR VPWR _079_ sky130_fd_sc_hd__inv_2
X_435_ net39 net37 net57 net58 VGND VGND VPWR VPWR _171_ sky130_fd_sc_hd__and4_1
X_504_ a_low\[1\] net40 _233_ VGND VGND VPWR VPWR _234_ sky130_fd_sc_hd__and3_1
XFILLER_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_418_ _154_ _155_ VGND VGND VPWR VPWR _157_ sky130_fd_sc_hd__xor2_1
XFILLER_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_752_ net60 VGND VGND VPWR VPWR _112_ sky130_fd_sc_hd__inv_2
X_683_ _375_ VGND VGND VPWR VPWR _376_ sky130_fd_sc_hd__inv_2
XFILLER_18_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_821_ clknet_3_1__leaf_clk net2 _109_ VGND VGND VPWR VPWR a_low\[1\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_8_Left_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_597_ _305_ _306_ VGND VGND VPWR VPWR _021_ sky130_fd_sc_hd__xnor2_1
XFILLER_29_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_666_ _359_ _360_ VGND VGND VPWR VPWR _361_ sky130_fd_sc_hd__nand2b_1
X_735_ net64 VGND VGND VPWR VPWR _095_ sky130_fd_sc_hd__inv_2
X_804_ clknet_3_3__leaf_clk _011_ _092_ VGND VGND VPWR VPWR pp2\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_26_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_520_ _235_ _249_ _236_ VGND VGND VPWR VPWR _250_ sky130_fd_sc_hd__o21ba_1
XFILLER_32_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_649_ _335_ _343_ _344_ VGND VGND VPWR VPWR _345_ sky130_fd_sc_hd__nand3b_1
XFILLER_17_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_451_ _183_ _184_ VGND VGND VPWR VPWR _185_ sky130_fd_sc_hd__nor2_1
X_718_ net63 VGND VGND VPWR VPWR _078_ sky130_fd_sc_hd__inv_2
X_382_ net59 VGND VGND VPWR VPWR _052_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_24_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_21_Left_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_434_ net39 net57 net58 net37 VGND VGND VPWR VPWR _170_ sky130_fd_sc_hd__a22oi_1
X_503_ _230_ _232_ VGND VGND VPWR VPWR _233_ sky130_fd_sc_hd__nor2_1
XFILLER_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_417_ _154_ _155_ VGND VGND VPWR VPWR _156_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_24_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_682_ _369_ _373_ VGND VGND VPWR VPWR _375_ sky130_fd_sc_hd__xor2_1
X_820_ clknet_3_1__leaf_clk net1 _108_ VGND VGND VPWR VPWR a_low\[0\] sky130_fd_sc_hd__dfrtp_1
X_751_ net59 VGND VGND VPWR VPWR _111_ sky130_fd_sc_hd__inv_2
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_29_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_596_ _295_ _299_ _301_ _298_ VGND VGND VPWR VPWR _306_ sky130_fd_sc_hd__a31o_1
X_803_ clknet_3_4__leaf_clk _047_ _091_ VGND VGND VPWR VPWR pp1\[7\] sky130_fd_sc_hd__dfrtp_1
X_665_ _343_ _345_ VGND VGND VPWR VPWR _360_ sky130_fd_sc_hd__nand2_1
X_734_ net63 VGND VGND VPWR VPWR _094_ sky130_fd_sc_hd__inv_2
XFILLER_6_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_450_ net36 net57 _181_ _182_ VGND VGND VPWR VPWR _184_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_31_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_579_ _290_ _291_ VGND VGND VPWR VPWR _292_ sky130_fd_sc_hd__and2_1
X_648_ _341_ _342_ _329_ VGND VGND VPWR VPWR _344_ sky130_fd_sc_hd__a21o_1
XFILLER_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_717_ net63 VGND VGND VPWR VPWR _077_ sky130_fd_sc_hd__inv_2
X_433_ _168_ _169_ VGND VGND VPWR VPWR _046_ sky130_fd_sc_hd__nor2_1
XFILLER_22_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_502_ _225_ _227_ _229_ VGND VGND VPWR VPWR _232_ sky130_fd_sc_hd__nor3_1
XFILLER_7_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_416_ a_high\[0\] net35 _138_ _137_ VGND VGND VPWR VPWR _155_ sky130_fd_sc_hd__a31o_1
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_681_ _369_ _373_ VGND VGND VPWR VPWR _374_ sky130_fd_sc_hd__nand2_1
XFILLER_18_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_750_ net59 VGND VGND VPWR VPWR _110_ sky130_fd_sc_hd__inv_2
XFILLER_34_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_595_ _303_ _304_ VGND VGND VPWR VPWR _305_ sky130_fd_sc_hd__nand2_1
X_802_ clknet_3_4__leaf_clk _051_ _090_ VGND VGND VPWR VPWR pp1\[6\] sky130_fd_sc_hd__dfrtp_1
X_664_ _357_ _358_ VGND VGND VPWR VPWR _359_ sky130_fd_sc_hd__nand2_1
XFILLER_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_733_ net63 VGND VGND VPWR VPWR _093_ sky130_fd_sc_hd__inv_2
XFILLER_26_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput30 net30 VGND VGND VPWR VPWR product[6] sky130_fd_sc_hd__buf_2
XFILLER_31_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_578_ middle_sum\[4\] pp3\[0\] VGND VGND VPWR VPWR _291_ sky130_fd_sc_hd__or2_1
X_647_ _329_ _341_ _342_ VGND VGND VPWR VPWR _343_ sky130_fd_sc_hd__nand3_1
X_716_ net59 VGND VGND VPWR VPWR _076_ sky130_fd_sc_hd__inv_2
.ends
