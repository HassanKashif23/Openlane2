* NGSPICE file created from mult.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_4 abstract view
.subckt sky130_fd_sc_hd__o21ba_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_4 abstract view
.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_4 abstract view
.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s4s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s4s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

.subckt mult VGND VPWR a[0] a[1] a[2] a[3] a[4] a[5] a[6] a[7] b[0] b[1] b[2] b[3]
+ b[4] b[5] b[6] b[7] clk product[0] product[10] product[11] product[12] product[13]
+ product[14] product[15] product[1] product[2] product[3] product[4] product[5] product[6]
+ product[7] product[8] product[9] rst
XTAP_TAPCELL_ROW_52_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer7 _0420_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_9_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1270_ net35 VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__inv_2
X_0985_ pp3\[14\]\[1\] pp3\[11\]\[1\] _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_14_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1399_ clknet_leaf_6_clk _0039_ _0250_ VGND VGND VPWR VPWR g5_5\[2\] sky130_fd_sc_hd__dfrtp_1
X_1468_ clknet_leaf_7_clk _0093_ _0319_ VGND VGND VPWR VPWR pp3\[13\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_42_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0770_ a0\[0\] b3\[0\] VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__and2_1
XFILLER_5_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1322_ clknet_leaf_16_clk net169 _0173_ VGND VGND VPWR VPWR mid_8\[3\] sky130_fd_sc_hd__dfrtp_1
X_1253_ net39 VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__inv_2
X_1184_ net36 VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_19_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0968_ _0105_ _0606_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__nor2_1
X_0899_ pp3\[12\]\[3\] _0550_ _0549_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__a21oi_1
XFILLER_30_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0822_ g5_5\[2\] g4_5\[4\] VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__xor2_1
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0753_ a1\[1\] b1\[0\] a1\[0\] b1\[1\] VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__a22oi_1
X_0684_ part1_7\[8\] _0405_ _0408_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__or3_4
XFILLER_49_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1236_ net37 VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__inv_2
X_1305_ clknet_leaf_16_clk net195 _0156_ VGND VGND VPWR VPWR sum_9\[2\] sky130_fd_sc_hd__dfrtp_1
X_1098_ net60 VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__inv_2
X_1167_ net44 VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_30_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1021_ _0379_ _0567_ g1_5\[3\] VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__o21ba_1
X_0805_ _0483_ _0486_ _0488_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__o21a_1
X_0736_ pp3\[1\]\[0\] pp3\[4\]\[0\] _0444_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__and3_1
X_0667_ part0_7\[5\] part1_7\[5\] VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__and2_4
XFILLER_37_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1219_ net53 VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__inv_2
XFILLER_52_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold63 pp2\[3\]\[3\] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 b[0] VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 mid_8\[6\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 part1_6\[9\] VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold85 pp2\[7\]\[2\] VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlygate4sd3_1
Xhold96 g1_4\[3\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_41_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer17 g2_5\[3\] VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dlygate4sd1_1
X_1004_ b3\[1\] a3\[1\] VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__nand2_1
XFILLER_34_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0719_ _0431_ _0433_ _0427_ _0429_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__a211oi_1
Xoutput20 net20 VGND VGND VPWR VPWR product[11] sky130_fd_sc_hd__buf_2
XFILLER_31_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput31 net31 VGND VGND VPWR VPWR product[7] sky130_fd_sc_hd__buf_2
XFILLER_31_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1484_ clknet_leaf_21_clk _0054_ _0335_ VGND VGND VPWR VPWR pp2\[1\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer8 _0425_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_9_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0984_ pp3\[14\]\[0\] pp3\[11\]\[0\] _0617_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_14_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1398_ clknet_leaf_6_clk _0038_ _0249_ VGND VGND VPWR VPWR g5_5\[1\] sky130_fd_sc_hd__dfrtp_1
X_1467_ clknet_leaf_7_clk _0095_ _0318_ VGND VGND VPWR VPWR pp3\[13\]\[2\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_19_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold160 g4_5\[2\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1321_ clknet_leaf_16_clk net182 _0172_ VGND VGND VPWR VPWR mid_8\[2\] sky130_fd_sc_hd__dfrtp_1
X_1252_ net36 VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__inv_2
X_1183_ net36 VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_19_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0967_ _0605_ _0606_ _0607_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__o21a_1
X_0898_ pp3\[9\]\[3\] _0547_ _0546_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a21oi_1
X_1519_ clknet_leaf_22_clk net11 _0370_ VGND VGND VPWR VPWR b1\[0\] sky130_fd_sc_hd__dfrtp_4
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_4_Left_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0821_ g5_5\[2\] g4_5\[4\] VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__and2_1
X_0752_ b1\[1\] a1\[1\] _0045_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__and3_1
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0683_ _0405_ _0408_ part1_7\[8\] VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__o21ai_1
X_1166_ net43 VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__inv_2
X_1235_ net37 VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__inv_2
X_1304_ clknet_leaf_16_clk net130 _0155_ VGND VGND VPWR VPWR sum_9\[1\] sky130_fd_sc_hd__dfrtp_1
X_1097_ net60 VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_22_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1020_ net232 net97 VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__xnor2_1
X_0804_ pp3\[13\]\[3\] _0479_ _0478_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__a21bo_1
X_0735_ _0444_ _0445_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__and2b_1
X_0666_ _0381_ _0395_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__and2_1
XFILLER_52_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1149_ net56 VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__inv_2
X_1218_ net53 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_50_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold75 part2_7\[13\] VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 part1_6\[11\] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 part1_6\[12\] VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 part0_6\[3\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 b[2] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 sum_9\[6\] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1003_ _0628_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__inv_2
X_0718_ _0429_ _0427_ _0431_ _0433_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0649_ g3_5\[2\] g2_5\[4\] VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__nor2_1
XFILLER_40_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput21 net21 VGND VGND VPWR VPWR product[12] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_33_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput32 net32 VGND VGND VPWR VPWR product[8] sky130_fd_sc_hd__buf_2
XFILLER_31_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1483_ clknet_leaf_21_clk _0056_ _0334_ VGND VGND VPWR VPWR pp2\[1\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer9 _0541_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_8_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0983_ pp3\[14\]\[0\] pp3\[11\]\[0\] VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__nand2_1
X_1397_ clknet_leaf_9_clk _0037_ _0248_ VGND VGND VPWR VPWR g5_5\[0\] sky130_fd_sc_hd__dfrtp_1
X_1466_ clknet_leaf_7_clk _0094_ _0317_ VGND VGND VPWR VPWR pp3\[13\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_10_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold161 _0042_ VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold150 pp2\[0\]\[1\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_37_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1320_ clknet_leaf_17_clk net172 _0171_ VGND VGND VPWR VPWR mid_8\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_11_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1182_ net36 VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__inv_2
X_1251_ net39 VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_19_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_20_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0897_ _0551_ _0552_ _0556_ _0555_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__o211a_1
X_0966_ b1\[0\] a2\[1\] a2\[0\] b1\[1\] VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__a22o_1
X_1518_ clknet_leaf_22_clk net10 _0369_ VGND VGND VPWR VPWR b0\[1\] sky130_fd_sc_hd__dfrtp_4
X_1449_ clknet_leaf_1_clk _0105_ _0300_ VGND VGND VPWR VPWR pp3\[9\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0820_ g5_5\[0\] net225 VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__xor2_1
XFILLER_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0751_ _0045_ a1\[1\] b1\[1\] VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__and3b_1
X_1303_ clknet_leaf_16_clk net145 _0154_ VGND VGND VPWR VPWR sum_9\[0\] sky130_fd_sc_hd__dfrtp_1
X_0682_ _0406_ net85 VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_47_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1096_ net60 VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_39_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1234_ net37 VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__inv_2
X_1165_ net41 VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_22_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0949_ _0586_ _0589_ _0597_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__or3b_4
XFILLER_20_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0803_ _0486_ _0487_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__and2b_1
X_0734_ pp3\[1\]\[0\] pp3\[4\]\[0\] VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__nand2_1
X_0665_ g3_5\[0\] g2_5\[2\] VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__or2_1
XFILLER_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1148_ net56 VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__inv_2
XFILLER_40_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1217_ net53 VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__inv_2
X_1079_ net50 VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_50_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold76 part2_7\[11\] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 mid_8\[1\] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 part0_6\[5\] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 a[3] VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 part1_6\[7\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 part1_6\[8\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_51_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1002_ b3\[0\] a3\[0\] VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__nand2_1
Xrebuffer19 _0413_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_2
X_0717_ part2_8\[12\] mid_8\[12\] VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__nand2_1
X_0648_ _0382_ _0383_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__nor2_1
XFILLER_25_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput22 net22 VGND VGND VPWR VPWR product[13] sky130_fd_sc_hd__buf_2
Xoutput33 net33 VGND VGND VPWR VPWR product[9] sky130_fd_sc_hd__buf_2
XFILLER_0_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1482_ clknet_leaf_21_clk _0055_ _0333_ VGND VGND VPWR VPWR pp2\[1\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0982_ pp3\[14\]\[1\] pp3\[11\]\[1\] VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__xor2_1
XFILLER_12_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1465_ clknet_leaf_7_clk _0092_ _0316_ VGND VGND VPWR VPWR pp3\[13\]\[0\] sky130_fd_sc_hd__dfrtp_1
X_1396_ clknet_leaf_6_clk _0065_ _0247_ VGND VGND VPWR VPWR g4_5\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold162 part1_7\[12\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 part2_7\[9\] VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dlygate4sd3_1
Xhold151 pp2\[4\]\[3\] VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1181_ net51 VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__inv_2
X_1250_ net35 VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__inv_2
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0896_ _0551_ _0552_ _0536_ net74 VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__a211o_1
X_0965_ _0605_ _0606_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__nor2_1
X_1517_ clknet_leaf_22_clk net9 _0368_ VGND VGND VPWR VPWR b0\[0\] sky130_fd_sc_hd__dfrtp_4
X_1448_ clknet_leaf_1_clk _0075_ _0299_ VGND VGND VPWR VPWR pp3\[8\]\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_2_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1379_ clknet_leaf_19_clk net148 _0230_ VGND VGND VPWR VPWR g2_5\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_48_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0750_ b1\[0\] a1\[0\] VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__and2_1
X_0681_ _0407_ _0406_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__nor2_2
X_1302_ clknet_leaf_10_clk net167 _0153_ VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dfrtp_1
X_1233_ net37 VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__inv_2
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1095_ net58 VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__inv_2
X_1164_ net41 VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__inv_2
X_0948_ _0586_ _0589_ _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__o21ba_4
XFILLER_20_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0879_ pp3\[12\]\[1\] _0540_ _0539_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__a21oi_4
XFILLER_28_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0802_ _0472_ _0477_ _0485_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__or3b_1
X_0664_ net223 _0393_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__xnor2_1
X_0733_ pp3\[1\]\[1\] pp3\[4\]\[1\] VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__xor2_1
XFILLER_6_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1216_ net42 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__inv_2
XFILLER_52_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1147_ net60 VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_35_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1078_ net49 VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__inv_2
Xhold77 part2_7\[12\] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold44 b[6] VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 pp2\[7\]\[3\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 sum_9\[9\] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 pp3\[0\]\[1\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 g2_5\[1\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1001_ _0117_ _0626_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__nor2_1
XFILLER_34_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0716_ part2_8\[12\] mid_8\[12\] VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__and2_1
X_0647_ _0380_ g2_5\[2\] g3_5\[0\] VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__and3_1
XFILLER_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput23 net23 VGND VGND VPWR VPWR product[14] sky130_fd_sc_hd__buf_2
XFILLER_48_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1481_ clknet_leaf_21_clk _0053_ _0332_ VGND VGND VPWR VPWR pp2\[1\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_7_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0981_ _0614_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__nor2_1
XFILLER_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1395_ clknet_leaf_6_clk _0069_ _0246_ VGND VGND VPWR VPWR g4_5\[4\] sky130_fd_sc_hd__dfrtp_1
X_1464_ clknet_leaf_2_clk _0114_ _0315_ VGND VGND VPWR VPWR pp3\[12\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold141 part2_7\[14\] VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlygate4sd3_1
Xhold130 mid_8\[2\] VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dlygate4sd3_1
Xhold152 g1_4\[0\] VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
Xhold163 pp3\[1\]\[3\] VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_21_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
X_1180_ net52 VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_12_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
X_0964_ b1\[1\] a2\[1\] VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__nand2_1
X_1516_ clknet_leaf_5_clk net8 _0367_ VGND VGND VPWR VPWR a3\[1\] sky130_fd_sc_hd__dfrtp_4
X_0895_ _0542_ _0553_ _0544_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_2_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1378_ clknet_leaf_18_clk net212 _0229_ VGND VGND VPWR VPWR g1_5\[4\] sky130_fd_sc_hd__dfrtp_1
X_1447_ clknet_leaf_1_clk _0077_ _0298_ VGND VGND VPWR VPWR pp3\[8\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_23_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0680_ _0403_ _0400_ _0401_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__a21boi_2
X_1301_ clknet_leaf_10_clk net201 _0152_ VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dfrtp_1
X_1232_ net38 VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_1_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_52_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1094_ net58 VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__inv_2
X_1163_ net41 VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__inv_2
X_0947_ _0595_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__or2_4
X_0878_ _0538_ _0537_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__xnor2_4
XFILLER_18_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload0 clknet_1_0__leaf_clk VGND VGND VPWR VPWR clkload0/X sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_44_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0801_ _0472_ _0477_ _0485_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__o21ba_4
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0732_ _0418_ _0443_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__and2_1
X_0663_ _0389_ _0392_ net230 net223 VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__o211a_1
XFILLER_6_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1146_ net60 VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__inv_2
X_1215_ net41 VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__inv_2
X_1077_ net49 VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__inv_2
Xhold45 b[1] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 a[0] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 mid_8\[5\] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold89 sum_9\[11\] VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 part0_6\[1\] VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 sum_9\[4\] VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd3_1
X_1000_ _0625_ _0626_ _0627_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__o21a_1
XFILLER_34_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0715_ part2_8\[12\] mid_8\[12\] VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__or2_1
X_0646_ _0380_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__and2b_1
X_1129_ net43 VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__inv_2
XFILLER_25_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput24 net24 VGND VGND VPWR VPWR product[15] sky130_fd_sc_hd__buf_2
XFILLER_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1480_ clknet_leaf_20_clk _0050_ _0331_ VGND VGND VPWR VPWR pp2\[0\]\[3\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0980_ pp3\[14\]\[2\] pp3\[11\]\[2\] VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__nor2_1
X_1394_ clknet_leaf_6_clk _0068_ _0245_ VGND VGND VPWR VPWR g4_5\[3\] sky130_fd_sc_hd__dfrtp_1
X_1463_ clknet_leaf_1_clk _0116_ _0314_ VGND VGND VPWR VPWR pp3\[12\]\[2\] sky130_fd_sc_hd__dfrtp_1
Xhold142 part2_7\[15\] VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlygate4sd3_1
Xhold153 part2_8\[15\] VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
Xhold120 pp2\[7\]\[1\] VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlygate4sd3_1
Xhold131 pp2\[4\]\[0\] VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlygate4sd3_1
Xhold164 _0453_ VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0963_ _0605_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__inv_2
X_0894_ _0553_ _0554_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__xor2_1
X_1515_ clknet_leaf_4_clk net7 _0366_ VGND VGND VPWR VPWR a3\[0\] sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_2_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1377_ clknet_leaf_18_clk net161 _0228_ VGND VGND VPWR VPWR g1_5\[3\] sky130_fd_sc_hd__dfrtp_1
X_1446_ clknet_leaf_1_clk _0076_ _0297_ VGND VGND VPWR VPWR pp3\[8\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_23_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1300_ clknet_leaf_10_clk net160 _0151_ VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dfrtp_1
X_1231_ net37 VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__inv_2
X_1162_ net41 VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__inv_2
X_1093_ net63 VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_47_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0946_ _0593_ _0594_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__and2_1
XFILLER_20_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0877_ _0538_ _0537_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__and2b_1
X_1429_ clknet_leaf_22_clk net196 _0280_ VGND VGND VPWR VPWR pp3\[4\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_34_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload1 clknet_leaf_0_clk VGND VGND VPWR VPWR clkload1/X sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_21_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0800_ _0483_ _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__or2_1
X_0731_ part2_8\[8\] mid_8\[8\] VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__or2_1
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0662_ _0393_ _0394_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__and2_4
X_1145_ net58 VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__inv_2
XFILLER_37_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1214_ net41 VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__inv_2
XFILLER_52_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1076_ net49 VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__inv_2
X_0929_ _0578_ net80 VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__xnor2_1
Xhold46 b[7] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 g4_5\[1\] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 a[1] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 sum_9\[5\] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 pp2\[6\]\[2\] VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0714_ _0429_ _0430_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__nor2_1
X_0645_ g3_5\[0\] g2_5\[2\] VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_27_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1128_ net44 VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__inv_2
X_1059_ net46 VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_11_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput25 net25 VGND VGND VPWR VPWR product[1] sky130_fd_sc_hd__buf_2
XFILLER_47_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1462_ clknet_leaf_1_clk _0115_ _0313_ VGND VGND VPWR VPWR pp3\[12\]\[1\] sky130_fd_sc_hd__dfrtp_1
X_1393_ clknet_leaf_9_clk _0067_ _0244_ VGND VGND VPWR VPWR g4_5\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold110 part0_6\[6\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlygate4sd3_1
Xhold165 g3_5\[4\] VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
Xhold154 part1_7\[10\] VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
Xhold121 sum_9\[3\] VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dlygate4sd3_1
Xhold143 pp2\[2\]\[0\] VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlygate4sd3_1
Xhold132 pp2\[3\]\[0\] VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0893_ _0526_ _0542_ _0543_ _0536_ net75 VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__o32a_1
X_0962_ b1\[0\] a2\[0\] VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__nand2_1
X_1514_ clknet_leaf_3_clk net6 _0365_ VGND VGND VPWR VPWR a2\[1\] sky130_fd_sc_hd__dfrtp_4
XFILLER_4_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1445_ clknet_leaf_20_clk _0074_ _0296_ VGND VGND VPWR VPWR pp3\[8\]\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_2_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1376_ clknet_leaf_18_clk net155 _0227_ VGND VGND VPWR VPWR g1_5\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_33_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout60 net64 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_4
XFILLER_14_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1092_ net63 VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__inv_2
X_1230_ net50 VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__inv_2
X_1161_ net41 VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_47_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0945_ _0594_ _0593_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__nor2_2
XFILLER_20_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0876_ pp3\[9\]\[1\] _0532_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__xnor2_2
X_1428_ clknet_leaf_3_clk net128 _0279_ VGND VGND VPWR VPWR pp3\[3\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_1359_ clknet_leaf_17_clk net222 _0210_ VGND VGND VPWR VPWR part0_6\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_41_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload2 clknet_leaf_1_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_21_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0730_ net218 _0441_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__xnor2_1
X_0661_ g3_5\[4\] _0389_ _0392_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__or3_4
X_1213_ net55 VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__inv_2
XFILLER_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1144_ net58 VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__inv_2
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1075_ net45 VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__inv_2
X_0928_ _0578_ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__and2b_1
X_0859_ pp3\[3\]\[0\] pp3\[6\]\[0\] VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__or2_4
Xhold69 g4_5\[0\] VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 a[5] VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 part0_6\[0\] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 b[4] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0713_ _0426_ _0428_ _0422_ net73 VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__a211oi_1
X_0644_ g2_5\[3\] g3_5\[1\] VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__xor2_1
X_1058_ net46 VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__inv_2
X_1127_ net44 VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__inv_2
XFILLER_15_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput26 net26 VGND VGND VPWR VPWR product[2] sky130_fd_sc_hd__buf_2
XFILLER_0_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1392_ clknet_leaf_8_clk _0066_ _0243_ VGND VGND VPWR VPWR g4_5\[1\] sky130_fd_sc_hd__dfrtp_1
X_1461_ clknet_leaf_1_clk _0113_ _0312_ VGND VGND VPWR VPWR pp3\[12\]\[0\] sky130_fd_sc_hd__dfrtp_1
Xclkbuf_leaf_15_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
Xhold111 part2_7\[10\] VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlygate4sd3_1
Xhold100 pp2\[1\]\[0\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold133 pp2\[5\]\[2\] VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dlygate4sd3_1
Xhold144 part1_6\[5\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dlygate4sd3_1
Xhold122 g2_4\[5\] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dlygate4sd3_1
Xhold155 pp3\[8\]\[0\] VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
Xhold166 g1_5\[4\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_26_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0961_ _0101_ _0603_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_10_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0892_ _0551_ _0552_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__xnor2_1
Xclkbuf_leaf_4_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
X_1444_ clknet_leaf_4_clk net153 _0295_ VGND VGND VPWR VPWR pp3\[7\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_1375_ clknet_leaf_18_clk net214 _0226_ VGND VGND VPWR VPWR g1_5\[1\] sky130_fd_sc_hd__dfrtp_1
X_1513_ clknet_leaf_0_clk net5 _0364_ VGND VGND VPWR VPWR a2\[0\] sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_2_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout61 net64 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_2
Xfanout50 net65 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_2
XFILLER_49_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1091_ net61 VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__inv_2
X_1160_ net43 VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__inv_2
X_0944_ pp3\[8\]\[2\] _0583_ _0581_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__a21oi_2
Xclkload20 clknet_leaf_17_clk VGND VGND VPWR VPWR clkload20/Y sky130_fd_sc_hd__clkinv_2
X_0875_ pp3\[9\]\[0\] net69 _0521_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__a21bo_4
X_1427_ clknet_leaf_2_clk net183 _0278_ VGND VGND VPWR VPWR pp3\[3\]\[2\] sky130_fd_sc_hd__dfrtp_1
X_1358_ clknet_leaf_17_clk net120 _0209_ VGND VGND VPWR VPWR part0_6\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_38_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1289_ clknet_leaf_16_clk net171 _0140_ VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__dfrtp_1
XFILLER_50_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload3 clknet_leaf_2_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_21_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0660_ _0389_ _0392_ g3_5\[4\] VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__o21ai_2
X_1212_ net55 VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__inv_2
XFILLER_37_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1143_ net58 VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__inv_2
X_1074_ net45 VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__inv_2
X_0927_ _0573_ pp3\[8\]\[0\] _0572_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__a21bo_1
X_0789_ pp3\[13\]\[1\] _0470_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__xnor2_1
X_0858_ net66 net67 VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__nand2_2
Xhold48 a[7] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 pp2\[0\]\[0\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 a[4] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0712_ _0425_ _0422_ _0426_ _0428_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__o211a_1
X_0643_ net47 VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__inv_2
X_1126_ net58 VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__inv_2
X_1057_ net45 VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__inv_2
Xoutput27 net27 VGND VGND VPWR VPWR product[3] sky130_fd_sc_hd__buf_2
XFILLER_0_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1109_ net48 VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1460_ clknet_leaf_5_clk _0118_ _0311_ VGND VGND VPWR VPWR pp3\[11\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_1391_ clknet_leaf_8_clk _0041_ _0242_ VGND VGND VPWR VPWR g4_5\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_50_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold112 pp2\[6\]\[3\] VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlygate4sd3_1
Xhold156 pp3\[0\]\[2\] VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dlygate4sd3_1
Xhold101 pp2\[0\]\[2\] VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
Xhold167 g1_5\[2\] VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 g2_4\[1\] VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
Xhold134 pp2\[2\]\[1\] VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 g2_4\[2\] VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0960_ _0602_ _0603_ _0604_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_10_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1512_ clknet_leaf_0_clk net4 _0363_ VGND VGND VPWR VPWR a1\[1\] sky130_fd_sc_hd__dfrtp_4
X_0891_ _0378_ _0535_ _0534_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__o21a_1
X_1443_ clknet_leaf_3_clk net150 _0294_ VGND VGND VPWR VPWR pp3\[7\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_4_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1374_ clknet_leaf_18_clk net217 _0225_ VGND VGND VPWR VPWR g1_5\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_2_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout62 net64 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_4
Xfanout51 net52 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_4
Xfanout40 net42 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_4
XFILLER_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1090_ net60 VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_30_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload10 clknet_leaf_21_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__inv_6
X_0943_ _0592_ pp3\[8\]\[3\] VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__xor2_2
X_0874_ _0378_ _0535_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__xnor2_2
Xclkload21 clknet_leaf_18_clk VGND VGND VPWR VPWR clkload21/Y sky130_fd_sc_hd__clkinv_4
XTAP_TAPCELL_ROW_38_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1357_ clknet_leaf_17_clk net181 _0208_ VGND VGND VPWR VPWR part0_6\[0\] sky130_fd_sc_hd__dfrtp_1
X_1288_ clknet_leaf_16_clk net127 _0139_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dfrtp_1
X_1426_ clknet_leaf_2_clk net194 _0277_ VGND VGND VPWR VPWR pp3\[3\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_43_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload4 clknet_leaf_3_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_44_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1211_ net54 VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__inv_2
XFILLER_37_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1142_ net57 VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__inv_2
XFILLER_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1073_ net44 VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__inv_2
X_0857_ _0084_ _0520_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__nor2_1
X_0926_ _0577_ pp3\[8\]\[1\] VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__xnor2_2
X_0788_ _0472_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__or2_1
Xhold38 a[2] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dlygate4sd3_1
X_1409_ clknet_leaf_19_clk _0098_ _0260_ VGND VGND VPWR VPWR g2_4\[2\] sky130_fd_sc_hd__dfrtp_1
Xhold49 a[6] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0711_ part2_8\[11\] mid_8\[11\] VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__nand2_1
XFILLER_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0642_ g1_5\[2\] VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__inv_2
X_1125_ net58 VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__inv_2
X_1056_ net45 VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__inv_2
XFILLER_21_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0909_ net98 pp3\[0\]\[3\] _0566_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__a21oi_2
Xoutput28 net28 VGND VGND VPWR VPWR product[4] sky130_fd_sc_hd__buf_2
XFILLER_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1039_ net58 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__inv_2
X_1108_ net47 VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__inv_2
XFILLER_21_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1390_ clknet_leaf_7_clk _0087_ _0241_ VGND VGND VPWR VPWR g3_5\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold102 sum_9\[15\] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
Xhold168 part1_7\[11\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
Xhold113 pp2\[4\]\[2\] VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlygate4sd3_1
Xhold157 _0001_ VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
Xhold146 part1_6\[4\] VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 part0_6\[7\] VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dlygate4sd3_1
Xhold135 pp2\[2\]\[2\] VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_37_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0890_ pp3\[12\]\[3\] _0550_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_27_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1442_ clknet_leaf_4_clk net185 _0293_ VGND VGND VPWR VPWR pp3\[7\]\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_10_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1511_ clknet_leaf_0_clk net3 _0362_ VGND VGND VPWR VPWR a1\[0\] sky130_fd_sc_hd__dfrtp_4
X_1373_ clknet_leaf_12_clk net129 _0224_ VGND VGND VPWR VPWR part1_7\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_23_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout63 net64 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_2
Xfanout52 net53 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_4
Xfanout41 net42 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_4
XFILLER_13_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload11 clknet_leaf_8_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__inv_8
XTAP_TAPCELL_ROW_30_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0942_ _0590_ _0591_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__nand2_4
X_0873_ _0530_ _0533_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__xnor2_2
X_1425_ clknet_leaf_1_clk net197 _0276_ VGND VGND VPWR VPWR pp3\[3\]\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_38_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1287_ clknet_leaf_16_clk net158 _0138_ VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__dfrtp_1
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1356_ clknet_leaf_13_clk net189 _0207_ VGND VGND VPWR VPWR part0_7\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload5 clknet_leaf_4_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_8
XFILLER_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Left_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1210_ net56 VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__inv_2
X_1072_ net46 VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__inv_2
X_1141_ net57 VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__inv_2
X_0787_ _0468_ _0471_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__and2_1
X_0856_ b2\[0\] a2\[1\] a2\[0\] b2\[1\] VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__a22oi_1
X_0925_ _0576_ _0575_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__nor2_8
Xhold39 b[5] VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_45_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1408_ clknet_leaf_19_clk _0097_ _0259_ VGND VGND VPWR VPWR g2_4\[1\] sky130_fd_sc_hd__dfrtp_1
X_1339_ clknet_leaf_10_clk net206 _0190_ VGND VGND VPWR VPWR part2_8\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_45_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0710_ part2_8\[11\] mid_8\[11\] VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__and2_1
X_0641_ pp3\[12\]\[2\] VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__inv_2
X_1055_ net62 VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__inv_2
X_1124_ net57 VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__inv_2
XFILLER_31_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0839_ _0508_ _0509_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__nor2_1
X_0908_ _0565_ pp3\[0\]\[2\] _0564_ g1_5\[0\] VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__and4_1
Xoutput18 net18 VGND VGND VPWR VPWR product[0] sky130_fd_sc_hd__buf_2
Xoutput29 net29 VGND VGND VPWR VPWR product[5] sky130_fd_sc_hd__buf_2
XFILLER_12_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_6_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1038_ net57 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_18_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1107_ net43 VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_8_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_32_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold136 sum_9\[14\] VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_7_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
Xhold158 g3_5\[5\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
Xhold103 part1_6\[10\] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
Xhold169 pp3\[0\]\[2\] VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
Xhold125 pp2\[4\]\[1\] VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dlygate4sd3_1
Xhold114 pp2\[5\]\[0\] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 g1_4\[4\] VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_26_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1441_ clknet_leaf_3_clk net137 _0292_ VGND VGND VPWR VPWR pp3\[7\]\[0\] sky130_fd_sc_hd__dfrtp_1
X_1510_ clknet_leaf_22_clk net2 _0361_ VGND VGND VPWR VPWR a0\[1\] sky130_fd_sc_hd__dfrtp_1
X_1372_ clknet_leaf_12_clk net118 _0223_ VGND VGND VPWR VPWR part1_7\[11\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_33_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout64 net65 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_2
Xfanout53 net65 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_4
Xfanout42 net65 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_2
XFILLER_13_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0941_ pp3\[2\]\[3\] pp3\[5\]\[3\] VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__or2_4
Xclkload12 clknet_leaf_9_clk VGND VGND VPWR VPWR clkload12/X sky130_fd_sc_hd__clkbuf_8
X_0872_ _0530_ _0533_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__or2_1
XFILLER_13_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1424_ clknet_leaf_0_clk net191 _0275_ VGND VGND VPWR VPWR pp3\[2\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_1355_ clknet_leaf_14_clk net175 _0206_ VGND VGND VPWR VPWR part0_7\[6\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_38_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1286_ clknet_leaf_12_clk _0006_ _0137_ VGND VGND VPWR VPWR part1_6\[12\] sky130_fd_sc_hd__dfrtp_1
Xclkload6 clknet_leaf_5_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__inv_6
XFILLER_24_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1071_ net63 VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_35_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1140_ net57 VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_43_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0924_ pp3\[5\]\[1\] pp3\[2\]\[1\] VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__nor2_4
X_0786_ _0468_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__nor2_2
X_0855_ b2\[1\] a2\[1\] _0083_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__and3_1
X_1338_ clknet_leaf_9_clk net140 _0189_ VGND VGND VPWR VPWR part2_8\[13\] sky130_fd_sc_hd__dfrtp_1
X_1407_ clknet_leaf_19_clk _0044_ _0258_ VGND VGND VPWR VPWR g2_4\[0\] sky130_fd_sc_hd__dfrtp_1
X_1269_ net55 VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__inv_2
XFILLER_43_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0640_ pp3\[12\]\[0\] VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__inv_2
XFILLER_2_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1054_ net62 VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__inv_2
X_1123_ net57 VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__inv_2
X_0907_ g1_5\[1\] pp3\[0\]\[3\] VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__or2_1
X_0838_ _0499_ _0507_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__and2_1
Xoutput19 net19 VGND VGND VPWR VPWR product[10] sky130_fd_sc_hd__buf_2
X_0769_ _0058_ _0460_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__nor2_1
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1106_ net43 VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__inv_2
XFILLER_53_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1037_ net57 VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_8_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold104 part0_7\[3\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
Xhold115 mid_8\[3\] VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dlygate4sd3_1
Xhold126 pp2\[2\]\[3\] VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd3_1
Xhold159 part1_7\[11\] VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
Xhold137 pp2\[1\]\[1\] VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlygate4sd3_1
Xhold148 pp2\[1\]\[3\] VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_4_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1440_ clknet_leaf_3_clk net177 _0291_ VGND VGND VPWR VPWR pp3\[6\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_1371_ clknet_leaf_12_clk net168 _0222_ VGND VGND VPWR VPWR part1_7\[10\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_1_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout65 net17 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_2
Xfanout54 net55 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_4
Xfanout43 net44 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_24_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0940_ pp3\[5\]\[3\] pp3\[2\]\[3\] VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__nand2_1
XFILLER_20_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload13 clknet_leaf_10_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__clkinv_4
X_0871_ pp3\[9\]\[1\] _0532_ _0531_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__a21oi_1
X_1285_ clknet_leaf_8_clk _0012_ _0136_ VGND VGND VPWR VPWR part1_6\[11\] sky130_fd_sc_hd__dfrtp_1
X_1354_ clknet_leaf_17_clk net119 _0205_ VGND VGND VPWR VPWR part0_7\[5\] sky130_fd_sc_hd__dfrtp_1
X_1423_ clknet_leaf_1_clk net200 _0274_ VGND VGND VPWR VPWR pp3\[2\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload7 clknet_leaf_6_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__inv_6
XFILLER_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1070_ net63 VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_35_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0854_ _0083_ a2\[1\] b2\[1\] VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__and3b_1
X_0923_ pp3\[2\]\[1\] pp3\[5\]\[1\] VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__and2_4
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0785_ _0470_ pp3\[13\]\[1\] _0469_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__a21oi_2
X_1337_ clknet_leaf_9_clk net142 _0188_ VGND VGND VPWR VPWR part2_8\[12\] sky130_fd_sc_hd__dfrtp_1
X_1268_ net54 VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__inv_2
X_1406_ clknet_leaf_19_clk _0031_ _0257_ VGND VGND VPWR VPWR g1_4\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1199_ net41 VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__inv_2
XFILLER_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1122_ net57 VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__inv_2
X_1053_ net62 VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__inv_2
X_0837_ _0499_ _0507_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__nor2_4
X_0906_ g1_5\[1\] pp3\[0\]\[3\] VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__nand2_1
X_0699_ part2_8\[8\] mid_8\[8\] VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__nand2_1
X_0768_ a0\[0\] b2\[1\] b2\[0\] net34 VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__a22oi_1
XFILLER_21_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1105_ net45 VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__inv_2
X_1036_ net57 VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__inv_2
XFILLER_21_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold105 pp2\[1\]\[2\] VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
Xhold149 g1_4\[1\] VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
Xhold116 pp3\[0\]\[0\] VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dlygate4sd3_1
Xhold138 pp2\[5\]\[1\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 g2_4\[4\] VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_53_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1019_ _0566_ _0634_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__nor2_1
XFILLER_40_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1370_ clknet_leaf_12_clk net139 _0221_ VGND VGND VPWR VPWR part1_7\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1499_ clknet_leaf_22_clk _0048_ _0350_ VGND VGND VPWR VPWR pp2\[5\]\[2\] sky130_fd_sc_hd__dfrtp_1
Xfanout55 net56 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_4
Xfanout44 net50 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_24_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0870_ pp3\[6\]\[1\] pp3\[3\]\[1\] VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__xor2_1
Xclkload14 clknet_leaf_11_clk VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__clkinv_4
X_1422_ clknet_leaf_0_clk net199 _0273_ VGND VGND VPWR VPWR pp3\[2\]\[1\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_50_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1284_ clknet_leaf_12_clk _0011_ _0135_ VGND VGND VPWR VPWR part1_6\[10\] sky130_fd_sc_hd__dfrtp_1
X_1353_ clknet_leaf_17_clk net125 _0204_ VGND VGND VPWR VPWR part0_7\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_46_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0999_ b3\[0\] a2\[1\] a2\[0\] b3\[1\] VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__a22o_1
Xclkload8 clknet_leaf_7_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__clkinv_8
XFILLER_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0853_ b2\[0\] a2\[0\] VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__and2_1
X_0922_ net220 _0574_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__xnor2_1
X_0784_ pp3\[10\]\[1\] pp3\[7\]\[1\] VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__xor2_2
X_1405_ clknet_leaf_20_clk _0035_ _0256_ VGND VGND VPWR VPWR g1_4\[3\] sky130_fd_sc_hd__dfrtp_1
X_1336_ clknet_leaf_9_clk net141 _0187_ VGND VGND VPWR VPWR part2_8\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1267_ net51 VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__inv_2
Xinput1 net99 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
X_1198_ net41 VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__inv_2
XFILLER_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1052_ net62 VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__inv_2
X_1121_ net48 VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__inv_2
XFILLER_25_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0836_ _0505_ _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__or2_4
X_0767_ net34 b2\[1\] _0057_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__and3_1
X_0905_ _0544_ _0563_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__and2_1
X_0698_ part2_8\[9\] mid_8\[9\] VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__xor2_1
X_1319_ clknet_leaf_16_clk net136 _0170_ VGND VGND VPWR VPWR mid_8\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1104_ net45 VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__inv_2
X_1035_ net57 VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__inv_2
XFILLER_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0819_ _0075_ _0492_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__nor2_1
XFILLER_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold117 part0_7\[2\] VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__dlygate4sd3_1
Xhold106 sum_9\[2\] VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold128 pp2\[5\]\[3\] VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlygate4sd3_1
Xhold139 pp2\[6\]\[0\] VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_41_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1018_ g1_5\[0\] net234 _0564_ _0565_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__a22oi_1
XFILLER_26_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1498_ clknet_leaf_22_clk _0047_ _0349_ VGND VGND VPWR VPWR pp2\[5\]\[1\] sky130_fd_sc_hd__dfrtp_1
Xfanout56 net65 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_4
Xfanout45 net46 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__buf_4
Xfanout34 a0\[1\] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_2
XFILLER_14_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload15 clknet_leaf_12_clk VGND VGND VPWR VPWR clkload15/X sky130_fd_sc_hd__clkbuf_8
XFILLER_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1421_ clknet_leaf_0_clk net208 _0272_ VGND VGND VPWR VPWR pp3\[2\]\[0\] sky130_fd_sc_hd__dfrtp_1
X_1352_ clknet_leaf_17_clk net151 _0203_ VGND VGND VPWR VPWR part0_7\[3\] sky130_fd_sc_hd__dfrtp_1
X_1283_ clknet_leaf_12_clk _0010_ _0134_ VGND VGND VPWR VPWR part1_6\[9\] sky130_fd_sc_hd__dfrtp_1
X_0998_ _0625_ _0626_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__nor2_1
Xclkload9 clknet_leaf_20_clk VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__clkinv_8
XFILLER_10_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0921_ _0572_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_23_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0852_ _0498_ _0519_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__and2_1
X_0783_ pp3\[10\]\[1\] pp3\[7\]\[1\] VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__and2_1
X_1335_ clknet_leaf_9_clk net176 _0186_ VGND VGND VPWR VPWR part2_8\[10\] sky130_fd_sc_hd__dfrtp_1
X_1404_ clknet_leaf_20_clk _0034_ _0255_ VGND VGND VPWR VPWR g1_4\[2\] sky130_fd_sc_hd__dfrtp_1
X_1197_ net54 VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__inv_2
Xinput2 net100 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
X_1266_ net40 VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__inv_2
XFILLER_51_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1051_ net62 VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__inv_2
XFILLER_18_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1120_ net48 VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__inv_2
X_0904_ _0526_ _0543_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__nand2_1
X_0835_ _0504_ _0503_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__and2_4
X_0697_ part2_8\[9\] mid_8\[9\] VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__and2_1
X_0766_ _0057_ b2\[1\] net34 VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__and3b_1
X_1318_ clknet_leaf_10_clk _0029_ _0169_ VGND VGND VPWR VPWR sum_9\[15\] sky130_fd_sc_hd__dfrtp_1
X_1249_ net35 VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__inv_2
XFILLER_24_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1103_ net44 VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__inv_2
X_1034_ net48 VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__inv_2
XFILLER_21_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0749_ _0445_ _0456_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_10_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0818_ b0\[0\] a2\[1\] a2\[0\] b0\[1\] VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__a22oi_1
XFILLER_12_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold118 pp2\[3\]\[2\] VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dlygate4sd3_1
Xhold107 part0_7\[1\] VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dlygate4sd3_1
Xhold129 pp2\[3\]\[1\] VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dlygate4sd3_1
X_1017_ _0561_ _0557_ _0560_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__o21bai_1
XFILLER_40_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1497_ clknet_leaf_22_clk _0045_ _0348_ VGND VGND VPWR VPWR pp2\[5\]\[0\] sky130_fd_sc_hd__dfrtp_1
Xfanout57 net64 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_32_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout46 net50 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_4
Xfanout35 net36 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_4
XFILLER_22_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload16 clknet_leaf_13_clk VGND VGND VPWR VPWR clkload16/Y sky130_fd_sc_hd__inv_6
X_1351_ clknet_leaf_17_clk net138 _0202_ VGND VGND VPWR VPWR part0_7\[2\] sky130_fd_sc_hd__dfrtp_1
X_1420_ clknet_leaf_20_clk net213 _0271_ VGND VGND VPWR VPWR pp3\[1\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_51_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1282_ clknet_leaf_12_clk _0009_ _0133_ VGND VGND VPWR VPWR part1_6\[8\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_21_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0997_ b3\[1\] a2\[1\] VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__nand2_1
XFILLER_40_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0920_ pp3\[5\]\[0\] pp3\[2\]\[0\] VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__or2_1
X_0851_ g5_5\[0\] g4_5\[2\] _0496_ _0497_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a22o_1
X_0782_ pp3\[13\]\[2\] _0467_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__xnor2_1
X_1334_ clknet_leaf_12_clk net205 _0185_ VGND VGND VPWR VPWR part2_8\[9\] sky130_fd_sc_hd__dfrtp_1
X_1403_ clknet_leaf_21_clk _0033_ _0254_ VGND VGND VPWR VPWR g1_4\[1\] sky130_fd_sc_hd__dfrtp_1
X_1265_ net39 VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1196_ net51 VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__inv_2
XFILLER_36_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput3 net103 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_40_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1050_ net59 VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__inv_2
X_0834_ _0504_ _0503_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__nor2_2
X_0903_ _0562_ _0557_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_47_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0696_ _0399_ _0415_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__and2_1
X_0765_ a0\[0\] b2\[0\] VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__and2_1
X_1317_ clknet_leaf_10_clk _0028_ _0168_ VGND VGND VPWR VPWR sum_9\[14\] sky130_fd_sc_hd__dfrtp_1
X_1248_ net36 VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__inv_2
XFILLER_2_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1179_ net52 VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__inv_2
XFILLER_46_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1102_ net46 VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__inv_2
X_1033_ net48 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__inv_2
X_0817_ b0\[1\] a2\[1\] _0074_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__and3_1
XFILLER_21_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0748_ pp3\[1\]\[0\] pp3\[4\]\[0\] VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__or2_1
X_0679_ _0404_ _0405_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__or2_1
XFILLER_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold108 sum_9\[8\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold119 pp2\[6\]\[1\] VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_19_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1016_ _0125_ _0632_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__nor2_1
Xclkbuf_leaf_20_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_11_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
X_1496_ clknet_leaf_22_clk _0126_ _0347_ VGND VGND VPWR VPWR pp2\[4\]\[3\] sky130_fd_sc_hd__dfrtp_1
Xfanout58 net64 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_32_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout36 net42 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_4
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout47 net48 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_4
XFILLER_22_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload17 clknet_leaf_14_clk VGND VGND VPWR VPWR clkload17/Y sky130_fd_sc_hd__inv_8
X_1350_ clknet_leaf_17_clk net143 _0201_ VGND VGND VPWR VPWR part0_7\[1\] sky130_fd_sc_hd__dfrtp_1
X_1281_ clknet_leaf_13_clk _0008_ _0132_ VGND VGND VPWR VPWR part1_6\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_51_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_0_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
X_0996_ _0625_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__inv_2
XFILLER_39_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1479_ clknet_leaf_20_clk _0052_ _0330_ VGND VGND VPWR VPWR pp2\[0\]\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_52_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0850_ _0517_ _0518_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__xnor2_1
X_0781_ pp3\[10\]\[2\] pp3\[7\]\[2\] VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__xor2_1
X_1402_ clknet_leaf_21_clk _0032_ _0253_ VGND VGND VPWR VPWR g1_4\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1333_ clknet_leaf_12_clk net146 _0184_ VGND VGND VPWR VPWR part2_8\[8\] sky130_fd_sc_hd__dfrtp_1
X_1264_ net35 VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__inv_2
Xinput4 net108 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
XFILLER_51_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1195_ net54 VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__inv_2
XFILLER_36_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0979_ pp3\[14\]\[2\] pp3\[11\]\[2\] VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__and2_1
XFILLER_27_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0833_ pp3\[15\]\[0\] _0494_ _0493_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__a21oi_2
X_0902_ _0560_ _0561_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__nor2_1
X_0764_ _0054_ _0459_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__nor2_1
X_0695_ part1_7\[4\] part0_7\[4\] VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__or2_1
X_1316_ clknet_leaf_10_clk _0027_ _0167_ VGND VGND VPWR VPWR sum_9\[13\] sky130_fd_sc_hd__dfrtp_1
X_1247_ net36 VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__inv_2
X_1178_ net40 VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__inv_2
XFILLER_24_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1101_ net61 VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__inv_2
XFILLER_38_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1032_ net47 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__inv_2
X_0747_ _0454_ _0455_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__xnor2_1
X_0816_ _0074_ a2\[1\] b0\[1\] VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__and3b_1
X_0678_ part1_7\[7\] part0_7\[7\] VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__and2_1
XFILLER_12_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold109 g2_4\[3\] VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlygate4sd3_1
X_1015_ _0631_ _0632_ _0633_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__o21a_1
XFILLER_19_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1495_ clknet_leaf_22_clk _0128_ _0346_ VGND VGND VPWR VPWR pp2\[4\]\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_49_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout37 net42 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_4
Xfanout59 net64 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_32_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout48 net50 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_4
XFILLER_9_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload18 clknet_leaf_15_clk VGND VGND VPWR VPWR clkload18/Y sky130_fd_sc_hd__clkinv_4
XFILLER_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1280_ clknet_leaf_13_clk _0007_ _0131_ VGND VGND VPWR VPWR part1_6\[6\] sky130_fd_sc_hd__dfrtp_1
X_0995_ b3\[0\] a2\[0\] VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__nand2_1
XFILLER_8_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1478_ clknet_leaf_21_clk _0051_ _0329_ VGND VGND VPWR VPWR pp2\[0\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_27_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0780_ pp3\[10\]\[2\] pp3\[7\]\[2\] VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__and2_1
X_1401_ clknet_leaf_6_clk _0036_ _0252_ VGND VGND VPWR VPWR g5_5\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1332_ clknet_leaf_9_clk _0013_ _0183_ VGND VGND VPWR VPWR mid_8\[13\] sky130_fd_sc_hd__dfrtp_1
X_1194_ net51 VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__inv_2
X_1263_ net35 VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__inv_2
Xinput5 net102 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
XFILLER_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0978_ _0611_ _0612_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__nor2_1
XFILLER_10_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0832_ _0502_ pp3\[15\]\[1\] VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__xnor2_2
XFILLER_41_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0901_ _0558_ _0559_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__and2_1
X_0763_ b1\[0\] net34 a0\[0\] b1\[1\] VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__a22oi_1
X_1315_ clknet_leaf_10_clk _0026_ _0166_ VGND VGND VPWR VPWR sum_9\[12\] sky130_fd_sc_hd__dfrtp_1
X_0694_ _0013_ _0414_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__nor2_1
X_1246_ net36 VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__inv_2
X_1177_ net39 VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__inv_2
XFILLER_32_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1100_ net61 VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__inv_2
X_1031_ _0618_ _0638_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__and2_1
X_0746_ _0448_ _0451_ _0449_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__o21a_1
X_0815_ b0\[0\] a2\[0\] VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__and2_1
X_0677_ part1_7\[7\] part0_7\[7\] VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__nor2_1
XFILLER_52_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1229_ net61 VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__inv_2
XFILLER_16_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1014_ a1\[0\] b0\[1\] b0\[0\] a1\[1\] VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_14_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0729_ _0441_ _0442_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_4_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1494_ clknet_leaf_22_clk _0127_ _0345_ VGND VGND VPWR VPWR pp2\[4\]\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_49_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout38 net42 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_4
XFILLER_22_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout49 net50 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_4
XFILLER_13_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload19 clknet_leaf_16_clk VGND VGND VPWR VPWR clkload19/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_48_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0994_ _0113_ _0623_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__nor2_1
X_1477_ clknet_leaf_17_clk _0049_ _0328_ VGND VGND VPWR VPWR pp2\[0\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_17_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1400_ clknet_leaf_6_clk _0040_ _0251_ VGND VGND VPWR VPWR g5_5\[3\] sky130_fd_sc_hd__dfrtp_1
X_1331_ clknet_leaf_9_clk _0022_ _0182_ VGND VGND VPWR VPWR mid_8\[12\] sky130_fd_sc_hd__dfrtp_1
Xinput6 net112 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
X_1193_ net51 VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__inv_2
X_1262_ net35 VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__inv_2
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0977_ pp3\[14\]\[3\] pp3\[11\]\[3\] VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__nor2_1
XFILLER_42_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Left_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0900_ _0558_ _0559_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__nor2_1
XFILLER_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0831_ g4_5\[5\] g5_5\[3\] VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__xor2_2
X_0693_ net84 net224 net227 VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__a21oi_1
X_0762_ b1\[1\] net34 _0053_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1314_ clknet_leaf_11_clk _0025_ _0165_ VGND VGND VPWR VPWR sum_9\[11\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1245_ net51 VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__inv_2
X_1176_ net40 VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_44_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1030_ pp3\[14\]\[0\] pp3\[11\]\[0\] VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__or2_1
X_0814_ _0071_ _0491_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__nor2_1
X_0745_ _0452_ _0453_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__and2b_1
X_0676_ _0402_ _0403_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__xnor2_1
X_1228_ net61 VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__inv_2
XFILLER_52_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1159_ net38 VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__inv_2
XFILLER_32_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1013_ _0631_ _0632_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__nor2_1
XFILLER_19_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_14_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
X_0728_ part2_8\[14\] _0437_ _0439_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__or3_4
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0659_ _0390_ _0391_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_4_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_3_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
X_1493_ clknet_leaf_22_clk _0125_ _0344_ VGND VGND VPWR VPWR pp2\[4\]\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_49_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout39 net42 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_4
XFILLER_22_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0993_ _0622_ _0623_ _0624_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__o21a_1
XFILLER_8_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1476_ clknet_leaf_6_clk _0122_ _0327_ VGND VGND VPWR VPWR pp3\[15\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1261_ net54 VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__inv_2
X_1330_ clknet_leaf_11_clk _0021_ _0181_ VGND VGND VPWR VPWR mid_8\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput7 net114 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
XFILLER_36_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1192_ net52 VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__inv_2
X_0976_ pp3\[14\]\[3\] pp3\[11\]\[3\] VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__and2_1
XFILLER_44_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1459_ clknet_leaf_5_clk _0120_ _0310_ VGND VGND VPWR VPWR pp3\[11\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_19_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0830_ g5_5\[3\] g4_5\[5\] VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__and2_1
XFILLER_33_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0692_ net233 _0413_ net227 VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__and3_1
X_0761_ _0053_ net34 b1\[1\] VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__and3b_1
X_1313_ clknet_leaf_11_clk _0024_ _0164_ VGND VGND VPWR VPWR sum_9\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1244_ net52 VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__inv_2
X_1175_ net39 VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__inv_2
XFILLER_24_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0959_ a1\[0\] b2\[1\] b2\[0\] a1\[1\] VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__a22o_1
XFILLER_46_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0813_ a1\[0\] b3\[1\] b3\[0\] a1\[1\] VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__a22oi_1
Xinput10 net110 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
X_0744_ net228 pp3\[4\]\[3\] VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__nand2_1
X_0675_ _0398_ part0_7\[4\] part1_7\[4\] _0396_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__a31o_4
X_1227_ net56 VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__inv_2
X_1158_ net38 VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__inv_2
XFILLER_52_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1089_ net60 VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__inv_2
XFILLER_20_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1012_ a1\[1\] b0\[1\] VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__nand2_1
XFILLER_19_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0727_ _0437_ net78 part2_8\[14\] VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_12_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0658_ _0390_ _0391_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_4_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1492_ clknet_leaf_3_clk _0062_ _0343_ VGND VGND VPWR VPWR pp2\[3\]\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_49_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0992_ b0\[0\] a3\[1\] a3\[0\] b0\[1\] VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a22o_1
XFILLER_5_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1475_ clknet_leaf_6_clk _0124_ _0326_ VGND VGND VPWR VPWR pp3\[15\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput8 net113 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
X_1260_ net51 VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__inv_2
X_1191_ net52 VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__inv_2
XFILLER_44_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0975_ _0109_ _0609_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__nor2_1
X_1458_ clknet_leaf_5_clk _0119_ _0309_ VGND VGND VPWR VPWR pp3\[11\]\[1\] sky130_fd_sc_hd__dfrtp_1
X_1389_ clknet_leaf_8_clk _0091_ _0240_ VGND VGND VPWR VPWR g3_5\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0760_ b1\[0\] a0\[0\] VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__and2_1
X_0691_ net224 net84 VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__xor2_1
XFILLER_49_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1312_ clknet_leaf_11_clk _0030_ _0163_ VGND VGND VPWR VPWR sum_9\[9\] sky130_fd_sc_hd__dfrtp_1
X_1243_ net52 VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__inv_2
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1174_ net35 VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__inv_2
X_0889_ _0545_ _0548_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__xor2_1
X_0958_ _0602_ _0603_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_53_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0812_ a1\[1\] b3\[1\] _0070_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__and3_1
X_0743_ net228 pp3\[4\]\[3\] VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__nor2_1
Xinput11 net107 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
X_0674_ _0400_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__nand2_1
Xclkbuf_1_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_1226_ net56 VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__inv_2
X_1157_ net38 VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__inv_2
XFILLER_52_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1088_ net60 VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__inv_2
XFILLER_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1011_ _0631_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__inv_2
XFILLER_34_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0726_ _0440_ _0439_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_12_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0657_ _0387_ _0384_ _0385_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__o21ai_2
X_1209_ net54 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__inv_2
XFILLER_25_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1491_ clknet_leaf_2_clk _0064_ _0342_ VGND VGND VPWR VPWR pp2\[3\]\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_49_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0709_ part2_8\[11\] mid_8\[11\] VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__or2_1
XFILLER_38_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0991_ _0622_ _0623_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__nor2_1
X_1474_ clknet_leaf_6_clk _0123_ _0325_ VGND VGND VPWR VPWR pp3\[15\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput9 net106 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
X_1190_ net40 VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_34_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0974_ _0608_ _0609_ _0610_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__o21a_1
X_1457_ clknet_leaf_5_clk _0117_ _0308_ VGND VGND VPWR VPWR pp3\[11\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1388_ clknet_leaf_8_clk _0090_ _0239_ VGND VGND VPWR VPWR g3_5\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_51_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0690_ net219 _0411_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__xor2_1
X_1311_ clknet_leaf_11_clk _0023_ _0162_ VGND VGND VPWR VPWR sum_9\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_49_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1173_ net38 VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1242_ net40 VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__inv_2
XFILLER_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0888_ _0545_ _0548_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__nor2_1
X_0957_ a1\[1\] b2\[1\] VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__nand2_1
X_1509_ clknet_leaf_22_clk net1 _0360_ VGND VGND VPWR VPWR a0\[0\] sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_53_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0811_ _0070_ b3\[1\] a1\[1\] VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__and3b_1
X_0742_ _0450_ _0451_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__xnor2_1
Xinput12 net105 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
X_0673_ part1_7\[6\] part0_7\[6\] VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__nand2_1
X_1225_ net55 VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__inv_2
XFILLER_37_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1087_ net64 VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_17_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
X_1156_ net37 VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__inv_2
XFILLER_20_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1010_ a1\[0\] b0\[0\] VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__nand2_1
XFILLER_8_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_6_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
X_0725_ _0436_ _0438_ _0432_ _0434_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__a211oi_1
X_0656_ _0388_ _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_12_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1208_ net53 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_4_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1139_ net50 VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__inv_2
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_9_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1490_ clknet_leaf_3_clk _0063_ _0341_ VGND VGND VPWR VPWR pp2\[3\]\[1\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0708_ _0423_ _0424_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__xnor2_1
X_0639_ part1_7\[9\] VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0990_ b0\[1\] a3\[1\] VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nand2_1
X_1473_ clknet_leaf_6_clk _0121_ _0324_ VGND VGND VPWR VPWR pp3\[15\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0973_ b2\[0\] a3\[1\] a3\[0\] b2\[1\] VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__a22o_1
X_1456_ clknet_leaf_5_clk _0084_ _0307_ VGND VGND VPWR VPWR pp3\[10\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_1387_ clknet_leaf_13_clk _0089_ _0238_ VGND VGND VPWR VPWR g3_5\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_38_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1241_ net39 VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_22_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1310_ clknet_leaf_15_clk net116 _0161_ VGND VGND VPWR VPWR sum_9\[7\] sky130_fd_sc_hd__dfrtp_1
X_1172_ net37 VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__inv_2
XFILLER_17_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0956_ _0602_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__inv_2
X_0887_ pp3\[9\]\[3\] _0547_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__xnor2_1
X_1508_ clknet_leaf_4_clk _0071_ _0359_ VGND VGND VPWR VPWR pp2\[7\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_1439_ clknet_leaf_2_clk net144 _0290_ VGND VGND VPWR VPWR pp3\[6\]\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_53_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0810_ a1\[0\] b3\[0\] VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__and2_1
XFILLER_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput13 net101 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
X_0741_ pp3\[1\]\[1\] pp3\[4\]\[1\] _0447_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__a21oi_1
X_0672_ part1_7\[6\] part0_7\[6\] VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__or2_1
X_1224_ net55 VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__inv_2
X_1086_ net59 VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__inv_2
X_1155_ net37 VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__inv_2
X_0939_ net79 _0588_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__xnor2_1
XFILLER_28_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0724_ _0434_ _0432_ _0436_ _0438_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__o211a_1
X_0655_ g3_5\[3\] g2_5\[5\] VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__and2_1
X_1207_ net54 VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__inv_2
X_1069_ net63 VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__inv_2
X_1138_ net48 VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__inv_2
XFILLER_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0707_ _0420_ _0416_ _0423_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_32_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1472_ clknet_leaf_5_clk _0110_ _0323_ VGND VGND VPWR VPWR pp3\[14\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0972_ _0608_ _0609_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__nor2_1
X_1524_ clknet_leaf_5_clk net16 _0375_ VGND VGND VPWR VPWR b3\[1\] sky130_fd_sc_hd__dfrtp_4
X_1455_ clknet_leaf_7_clk _0086_ _0306_ VGND VGND VPWR VPWR pp3\[10\]\[2\] sky130_fd_sc_hd__dfrtp_1
X_1386_ clknet_leaf_13_clk _0088_ _0237_ VGND VGND VPWR VPWR g3_5\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1171_ net37 VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__inv_2
XFILLER_1_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1240_ net40 VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__inv_2
X_0886_ pp3\[6\]\[3\] pp3\[3\]\[3\] VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__xor2_1
X_0955_ a1\[0\] b2\[0\] VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand2_1
X_1507_ clknet_leaf_3_clk _0073_ _0358_ VGND VGND VPWR VPWR pp2\[7\]\[2\] sky130_fd_sc_hd__dfrtp_1
X_1438_ clknet_leaf_0_clk net184 _0289_ VGND VGND VPWR VPWR pp3\[6\]\[1\] sky130_fd_sc_hd__dfrtp_1
X_1369_ clknet_leaf_12_clk net163 _0220_ VGND VGND VPWR VPWR part1_7\[8\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_53_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput14 net104 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
X_0740_ _0448_ _0449_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__and2b_1
XFILLER_14_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0671_ net91 _0399_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__xnor2_1
X_1154_ net56 VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__inv_2
X_1223_ net55 VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__inv_2
XFILLER_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1085_ net62 VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__inv_2
XFILLER_37_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0938_ _0586_ _0587_ _0580_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__nor3b_4
X_0869_ pp3\[6\]\[1\] pp3\[3\]\[1\] VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__and2_1
XFILLER_43_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_29_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0723_ part2_8\[13\] mid_8\[13\] VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__nand2_1
XFILLER_8_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0654_ g3_5\[3\] g2_5\[5\] VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__nor2_1
X_1206_ net52 VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__inv_2
X_1137_ net48 VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__inv_2
X_1068_ net62 VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_3_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0706_ _0416_ net71 VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__nor2_1
XFILLER_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1471_ clknet_leaf_5_clk _0112_ _0322_ VGND VGND VPWR VPWR pp3\[14\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0971_ b2\[1\] a3\[1\] VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__nand2_1
X_1523_ clknet_leaf_4_clk net15 _0374_ VGND VGND VPWR VPWR b3\[0\] sky130_fd_sc_hd__dfrtp_4
X_1454_ clknet_leaf_4_clk _0085_ _0305_ VGND VGND VPWR VPWR pp3\[10\]\[1\] sky130_fd_sc_hd__dfrtp_1
X_1385_ clknet_leaf_19_clk _0043_ _0236_ VGND VGND VPWR VPWR g3_5\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_50_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1170_ net37 VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__inv_2
XFILLER_32_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0885_ pp3\[6\]\[3\] pp3\[3\]\[3\] VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__and2_1
X_0954_ _0601_ _0096_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__nor2_1
X_1506_ clknet_leaf_4_clk _0072_ _0357_ VGND VGND VPWR VPWR pp2\[7\]\[1\] sky130_fd_sc_hd__dfrtp_1
X_1437_ clknet_leaf_0_clk net204 _0288_ VGND VGND VPWR VPWR pp3\[6\]\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_53_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1299_ clknet_leaf_10_clk net149 _0150_ VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dfrtp_1
X_1368_ clknet_leaf_13_clk net152 _0219_ VGND VGND VPWR VPWR part1_7\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_11_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput15 net109 VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
X_0670_ part1_7\[4\] part0_7\[4\] VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__nand2_1
X_1153_ net56 VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__inv_2
X_1222_ net55 VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__inv_2
X_1084_ net62 VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_9_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
X_0799_ _0481_ _0482_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__and2_1
X_0937_ _0586_ _0587_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__or2_1
X_0868_ pp3\[9\]\[2\] _0529_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__xnor2_1
XFILLER_51_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0722_ part2_8\[13\] mid_8\[13\] VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__and2_1
X_0653_ _0386_ net81 VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__xnor2_1
XFILLER_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1067_ net62 VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__inv_2
X_1205_ net51 VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__inv_2
X_1136_ net48 VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_3_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0705_ _0421_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_48_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1119_ net48 VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1470_ clknet_leaf_4_clk _0111_ _0321_ VGND VGND VPWR VPWR pp3\[14\]\[1\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_51_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0970_ _0608_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__inv_2
X_1522_ clknet_leaf_4_clk net14 _0373_ VGND VGND VPWR VPWR b2\[1\] sky130_fd_sc_hd__dfrtp_4
X_1453_ clknet_leaf_2_clk _0083_ _0304_ VGND VGND VPWR VPWR pp3\[10\]\[0\] sky130_fd_sc_hd__dfrtp_1
X_1384_ clknet_leaf_19_clk net187 _0235_ VGND VGND VPWR VPWR g2_5\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_27_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0884_ pp3\[9\]\[2\] _0529_ _0528_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__a21oi_1
X_0953_ _0595_ _0598_ _0600_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__nor3_2
X_1505_ clknet_leaf_3_clk _0070_ _0356_ VGND VGND VPWR VPWR pp2\[7\]\[0\] sky130_fd_sc_hd__dfrtp_1
X_1436_ clknet_leaf_1_clk net193 _0287_ VGND VGND VPWR VPWR pp3\[5\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_1367_ clknet_leaf_14_clk net135 _0218_ VGND VGND VPWR VPWR part1_7\[6\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_53_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1298_ clknet_leaf_11_clk net154 _0149_ VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dfrtp_1
XFILLER_23_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput16 net111 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
X_1221_ net56 VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__inv_2
X_1152_ net56 VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__inv_2
X_1083_ net62 VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__inv_2
X_0936_ _0584_ _0585_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__and2_1
XFILLER_20_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0798_ _0482_ _0481_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__nor2_2
X_0867_ pp3\[6\]\[2\] pp3\[3\]\[2\] VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__xor2_1
X_1419_ clknet_leaf_21_clk net170 _0270_ VGND VGND VPWR VPWR pp3\[1\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_51_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0721_ part2_8\[13\] mid_8\[13\] VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__or2_1
X_0652_ g3_5\[1\] net82 _0383_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__a21oi_2
XFILLER_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1204_ net53 VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__inv_2
X_1066_ net59 VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__inv_2
XFILLER_33_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1135_ net47 VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__inv_2
X_0919_ pp3\[5\]\[0\] pp3\[2\]\[0\] VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__nand2_1
XFILLER_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_29_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0704_ part2_8\[10\] mid_8\[10\] VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__and2_1
XFILLER_53_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1049_ net59 VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__inv_2
X_1118_ net47 VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__inv_2
XFILLER_21_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1452_ clknet_leaf_2_clk _0106_ _0303_ VGND VGND VPWR VPWR pp3\[9\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_1383_ clknet_leaf_19_clk net192 _0234_ VGND VGND VPWR VPWR g2_5\[4\] sky130_fd_sc_hd__dfrtp_1
X_1521_ clknet_leaf_0_clk net13 _0372_ VGND VGND VPWR VPWR b2\[0\] sky130_fd_sc_hd__dfrtp_4
XFILLER_35_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0952_ _0598_ _0595_ _0600_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__o21a_1
X_1504_ clknet_leaf_3_clk _0102_ _0355_ VGND VGND VPWR VPWR pp2\[6\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_0883_ _0542_ _0544_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__xor2_1
X_1435_ clknet_leaf_22_clk net198 _0286_ VGND VGND VPWR VPWR pp3\[5\]\[2\] sky130_fd_sc_hd__dfrtp_1
X_1366_ clknet_leaf_14_clk net209 _0217_ VGND VGND VPWR VPWR part1_7\[5\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_53_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1297_ clknet_leaf_11_clk net159 _0148_ VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dfrtp_1
XFILLER_23_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_1_Left_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput17 net115 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
X_1151_ net60 VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__inv_2
X_1220_ net53 VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__inv_2
XFILLER_45_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1082_ net59 VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__inv_2
X_0866_ pp3\[6\]\[2\] pp3\[3\]\[2\] VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__and2_1
X_0935_ _0584_ _0585_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__nor2_1
X_0797_ pp3\[13\]\[2\] _0467_ _0466_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_43_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1349_ clknet_leaf_17_clk net123 _0200_ VGND VGND VPWR VPWR part0_7\[0\] sky130_fd_sc_hd__dfrtp_1
X_1418_ clknet_leaf_21_clk net202 _0269_ VGND VGND VPWR VPWR pp3\[1\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0720_ _0435_ _0434_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__nor2_1
XFILLER_42_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0651_ _0384_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__and2b_1
X_1134_ net47 VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__inv_2
XFILLER_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1203_ net52 VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__inv_2
X_1065_ net59 VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__inv_2
XFILLER_33_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0849_ pp3\[15\]\[3\] _0511_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__xor2_1
X_0918_ _0092_ _0570_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_3_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_10_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
X_0703_ part2_8\[10\] mid_8\[10\] VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_48_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1117_ net47 VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__inv_2
X_1048_ net59 VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_8_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1520_ clknet_leaf_22_clk net12 _0371_ VGND VGND VPWR VPWR b1\[1\] sky130_fd_sc_hd__dfrtp_4
X_1382_ clknet_leaf_19_clk net174 _0233_ VGND VGND VPWR VPWR g2_5\[3\] sky130_fd_sc_hd__dfrtp_1
X_1451_ clknet_leaf_2_clk _0108_ _0302_ VGND VGND VPWR VPWR pp3\[9\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0951_ pp3\[8\]\[3\] _0591_ _0590_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__a21bo_1
X_0882_ _0543_ _0526_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__or2_4
X_1503_ clknet_leaf_2_clk _0104_ _0354_ VGND VGND VPWR VPWR pp2\[6\]\[2\] sky130_fd_sc_hd__dfrtp_1
X_1296_ clknet_leaf_11_clk net131 _0147_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dfrtp_1
X_1365_ clknet_leaf_14_clk net211 _0216_ VGND VGND VPWR VPWR part1_7\[4\] sky130_fd_sc_hd__dfrtp_1
X_1434_ clknet_leaf_1_clk net203 _0285_ VGND VGND VPWR VPWR pp3\[5\]\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_53_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1150_ net60 VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__inv_2
XFILLER_45_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1081_ net59 VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_15_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0934_ pp3\[8\]\[1\] _0577_ _0575_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__a21oi_1
X_0865_ _0526_ _0527_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__and2_4
X_0796_ pp3\[13\]\[3\] _0480_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__xor2_1
X_1417_ clknet_leaf_21_clk net165 _0268_ VGND VGND VPWR VPWR pp3\[1\]\[0\] sky130_fd_sc_hd__dfrtp_1
X_1348_ clknet_leaf_9_clk _0082_ _0199_ VGND VGND VPWR VPWR part2_7\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1279_ clknet_leaf_19_clk net164 _0130_ VGND VGND VPWR VPWR part1_6\[5\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_29_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0650_ g3_5\[2\] g2_5\[4\] VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__nand2_1
X_1064_ net59 VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__inv_2
X_1133_ net47 VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__inv_2
XFILLER_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1202_ net40 VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__inv_2
X_0848_ _0510_ _0511_ _0513_ _0515_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__o31a_1
X_0779_ _0464_ _0465_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__and2_1
X_0917_ _0569_ _0570_ _0571_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_3_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0702_ _0419_ net70 VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_0_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1116_ net47 VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__inv_2
X_1047_ net49 VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__inv_2
XFILLER_0_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1450_ clknet_leaf_2_clk _0107_ _0301_ VGND VGND VPWR VPWR pp3\[9\]\[1\] sky130_fd_sc_hd__dfrtp_1
X_1381_ clknet_leaf_19_clk net188 _0232_ VGND VGND VPWR VPWR g2_5\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0950_ _0598_ _0599_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__and2b_1
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0881_ _0540_ pp3\[12\]\[1\] VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__xnor2_2
X_1433_ clknet_leaf_22_clk net179 _0284_ VGND VGND VPWR VPWR pp3\[5\]\[0\] sky130_fd_sc_hd__dfrtp_1
X_1502_ clknet_leaf_0_clk _0103_ _0353_ VGND VGND VPWR VPWR pp2\[6\]\[1\] sky130_fd_sc_hd__dfrtp_1
X_1295_ clknet_leaf_11_clk net173 _0146_ VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dfrtp_1
X_1364_ clknet_leaf_13_clk _0000_ _0215_ VGND VGND VPWR VPWR part0_6\[7\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_53_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1080_ net59 VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__inv_2
XFILLER_52_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0795_ _0478_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__nand2_1
XFILLER_9_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0933_ pp3\[8\]\[2\] _0583_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__xnor2_1
X_0864_ _0377_ _0525_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__nand2_1
X_1347_ clknet_leaf_9_clk _0081_ _0198_ VGND VGND VPWR VPWR part2_7\[14\] sky130_fd_sc_hd__dfrtp_1
X_1416_ clknet_leaf_18_clk net157 _0267_ VGND VGND VPWR VPWR pp3\[0\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1278_ clknet_leaf_19_clk net156 _0129_ VGND VGND VPWR VPWR part1_6\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_47_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1201_ net39 VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__inv_2
X_1132_ net47 VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__inv_2
XFILLER_18_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1063_ net49 VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__inv_2
X_0916_ b1\[0\] a3\[1\] a3\[0\] b1\[1\] VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a22o_1
X_0847_ _0515_ _0516_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__and2_4
X_0778_ _0462_ _0463_ pp3\[13\]\[0\] VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__a21o_1
XFILLER_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0701_ _0417_ mid_8\[8\] part2_8\[8\] VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__and3_1
XFILLER_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1115_ net43 VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__inv_2
X_1046_ net49 VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_31_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1029_ _0613_ _0621_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__xnor2_1
XFILLER_14_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1380_ clknet_leaf_19_clk net210 _0231_ VGND VGND VPWR VPWR g2_5\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer20 _0407_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_26_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0880_ _0541_ _0536_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__xnor2_2
X_1432_ clknet_leaf_21_clk net216 _0283_ VGND VGND VPWR VPWR pp3\[4\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_1363_ clknet_leaf_13_clk _0005_ _0214_ VGND VGND VPWR VPWR part0_6\[6\] sky130_fd_sc_hd__dfrtp_1
X_1501_ clknet_leaf_0_clk _0101_ _0352_ VGND VGND VPWR VPWR pp2\[6\]\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_53_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1294_ clknet_leaf_15_clk net147 _0145_ VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__dfrtp_1
XFILLER_23_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0932_ _0581_ _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__nor2_4
X_0794_ pp3\[10\]\[3\] pp3\[7\]\[3\] VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__or2_1
X_0863_ _0525_ _0377_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__or2_4
X_1346_ clknet_leaf_9_clk _0080_ _0197_ VGND VGND VPWR VPWR part2_7\[13\] sky130_fd_sc_hd__dfrtp_1
X_1415_ clknet_leaf_18_clk net166 _0266_ VGND VGND VPWR VPWR pp3\[0\]\[2\] sky130_fd_sc_hd__dfrtp_1
X_1277_ net55 VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_5_Left_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_22_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_12_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1200_ net41 VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__inv_2
X_1131_ net43 VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__inv_2
X_1062_ net49 VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__inv_2
X_0915_ _0569_ _0570_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__nor2_1
Xclkbuf_leaf_13_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
X_0846_ _0505_ _0508_ _0514_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__or3_4
X_0777_ pp3\[13\]\[0\] _0462_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nand3_1
XFILLER_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1329_ clknet_leaf_12_clk _0020_ _0180_ VGND VGND VPWR VPWR mid_8\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0700_ _0417_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__and2b_1
XFILLER_38_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_2_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_0_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1114_ net43 VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__inv_2
X_1045_ net49 VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__inv_2
X_0829_ _0499_ _0500_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_31_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1028_ _0616_ _0620_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__xnor2_1
XFILLER_39_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_34_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer10 net74 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__buf_2
Xrebuffer32 _0567_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_25_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1500_ clknet_leaf_0_clk _0046_ _0351_ VGND VGND VPWR VPWR pp2\[5\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_1431_ clknet_leaf_22_clk net178 _0282_ VGND VGND VPWR VPWR pp3\[4\]\[2\] sky130_fd_sc_hd__dfrtp_1
X_1362_ clknet_leaf_18_clk _0004_ _0213_ VGND VGND VPWR VPWR part0_6\[5\] sky130_fd_sc_hd__dfrtp_1
X_1293_ clknet_leaf_15_clk net162 _0144_ VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_53_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_37_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0931_ pp3\[5\]\[2\] pp3\[2\]\[2\] VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_21_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0862_ _0524_ _0523_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__or2_4
X_0793_ pp3\[10\]\[3\] pp3\[7\]\[3\] VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__nand2_1
Xrebuffer1 pp3\[6\]\[0\] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dlymetal6s2s_1
X_1345_ clknet_leaf_9_clk _0079_ _0196_ VGND VGND VPWR VPWR part2_7\[12\] sky130_fd_sc_hd__dfrtp_1
X_1276_ net54 VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__inv_2
XFILLER_3_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1414_ clknet_leaf_18_clk net215 _0265_ VGND VGND VPWR VPWR pp3\[0\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_22_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1130_ net43 VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__inv_2
XFILLER_26_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1061_ net49 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__inv_2
XFILLER_18_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0845_ _0505_ _0508_ _0514_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__o21ai_2
X_0914_ b1\[1\] a3\[1\] VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__nand2_1
X_0776_ pp3\[10\]\[0\] pp3\[7\]\[0\] VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__or2_1
X_1259_ net54 VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__inv_2
X_1328_ clknet_leaf_12_clk _0019_ _0179_ VGND VGND VPWR VPWR mid_8\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_17_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1113_ net44 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_0_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1044_ net46 VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__inv_2
X_0828_ _0495_ _0496_ _0498_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_31_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0759_ _0050_ _0458_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__nor2_1
XFILLER_44_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_39_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1027_ _0619_ _0637_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_36_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold90 g1_4\[2\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer33 g1_5\[1\] VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_26_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1430_ clknet_leaf_22_clk net190 _0281_ VGND VGND VPWR VPWR pp3\[4\]\[1\] sky130_fd_sc_hd__dfrtp_1
X_1361_ clknet_leaf_18_clk _0003_ _0212_ VGND VGND VPWR VPWR part0_6\[4\] sky130_fd_sc_hd__dfrtp_1
X_1292_ clknet_leaf_15_clk net133 _0143_ VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dfrtp_1
XFILLER_36_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0792_ _0474_ _0476_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__xnor2_1
X_0930_ pp3\[5\]\[2\] pp3\[2\]\[2\] VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__and2_4
XFILLER_20_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer2 pp3\[3\]\[0\] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dlymetal6s2s_1
X_0861_ _0521_ net68 pp3\[9\]\[0\] VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__a21oi_1
X_1413_ clknet_leaf_17_clk net124 _0264_ VGND VGND VPWR VPWR pp3\[0\]\[0\] sky130_fd_sc_hd__dfrtp_1
X_1275_ net54 VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__inv_2
X_1344_ clknet_leaf_9_clk _0078_ _0195_ VGND VGND VPWR VPWR part2_7\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1060_ net49 VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__inv_2
XFILLER_18_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0844_ _0512_ _0513_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__xnor2_1
X_0775_ pp3\[10\]\[0\] pp3\[7\]\[0\] VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__nand2_1
X_0913_ _0569_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__inv_2
X_1258_ net51 VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__inv_2
X_1327_ clknet_leaf_11_clk _0018_ _0178_ VGND VGND VPWR VPWR mid_8\[8\] sky130_fd_sc_hd__dfrtp_1
X_1189_ net39 VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_49_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1043_ net45 VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__inv_2
X_1112_ net44 VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__inv_2
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0827_ _0496_ _0498_ _0495_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_31_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0758_ net34 b0\[0\] a0\[0\] b0\[1\] VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_39_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0689_ _0405_ _0408_ part1_7\[8\] part1_7\[9\] part1_7\[10\] VGND VGND VPWR VPWR
+ _0413_ sky130_fd_sc_hd__o2111a_1
XFILLER_47_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1026_ _0617_ _0618_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_36_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold80 mid_8\[0\] VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dlygate4sd3_1
Xhold91 g2_5\[0\] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_26_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1009_ _0452_ _0455_ net229 VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__o21ai_1
XFILLER_25_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1360_ clknet_leaf_17_clk _0002_ _0211_ VGND VGND VPWR VPWR part0_6\[3\] sky130_fd_sc_hd__dfrtp_1
X_1291_ clknet_leaf_15_clk net132 _0142_ VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dfrtp_1
XFILLER_31_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1489_ clknet_leaf_0_clk _0061_ _0340_ VGND VGND VPWR VPWR pp2\[3\]\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_52_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0791_ _0474_ _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__and2b_1
XFILLER_9_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer3 _0522_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dlymetal6s4s_1
X_0860_ _0522_ _0521_ pp3\[9\]\[0\] VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__and3_1
X_1343_ clknet_leaf_9_clk net226 _0194_ VGND VGND VPWR VPWR part2_7\[10\] sky130_fd_sc_hd__dfrtp_1
X_1412_ clknet_leaf_19_clk _0096_ _0263_ VGND VGND VPWR VPWR g2_4\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1274_ net40 VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_16_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_14_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0989_ _0622_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_6_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0912_ b1\[0\] a3\[0\] VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0843_ pp3\[15\]\[1\] _0502_ _0501_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__a21oi_1
X_0774_ _0062_ _0461_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__nor2_1
Xclkbuf_leaf_5_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
X_1326_ clknet_leaf_14_clk _0017_ _0177_ VGND VGND VPWR VPWR mid_8\[7\] sky130_fd_sc_hd__dfrtp_1
X_1257_ net51 VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__inv_2
X_1188_ net38 VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__inv_2
XFILLER_17_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1042_ net45 VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__inv_2
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1111_ net44 VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_31_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0826_ g5_5\[0\] g4_5\[2\] _0496_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__nand4_1
X_0688_ _0411_ _0412_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__nor2_1
X_0757_ net34 b0\[1\] _0049_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__and3_1
X_1309_ clknet_leaf_15_clk net117 _0160_ VGND VGND VPWR VPWR sum_9\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_29_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1025_ g1_5\[0\] net221 VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__xor2_1
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0809_ _0476_ _0490_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__nor2_1
XFILLER_44_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold81 part2_7\[8\] VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dlygate4sd3_1
Xhold92 pp2\[0\]\[3\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
Xhold70 part1_6\[6\] VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer13 _0439_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dlymetal6s2s_1
X_1008_ _0121_ _0629_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__nor2_1
XFILLER_34_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1290_ clknet_leaf_16_clk net186 _0141_ VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1488_ clknet_leaf_0_clk _0058_ _0339_ VGND VGND VPWR VPWR pp2\[2\]\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_52_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0790_ _0462_ _0464_ _0475_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__a21oi_1
Xrebuffer4 _0522_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_2
X_1342_ clknet_leaf_8_clk net122 _0193_ VGND VGND VPWR VPWR part2_7\[9\] sky130_fd_sc_hd__dfrtp_1
X_1273_ net36 VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__inv_2
X_1411_ clknet_leaf_19_clk _0100_ _0262_ VGND VGND VPWR VPWR g2_4\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_51_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0988_ b0\[0\] a3\[0\] VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__nand2_1
XFILLER_47_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_25_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0842_ _0510_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__nor2_1
X_0911_ net231 _0568_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__and2_1
XFILLER_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0773_ a0\[0\] b3\[1\] b3\[0\] a0\[1\] VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__a22oi_1
X_1325_ clknet_leaf_14_clk _0016_ _0176_ VGND VGND VPWR VPWR mid_8\[6\] sky130_fd_sc_hd__dfrtp_1
X_1256_ net52 VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__inv_2
X_1187_ net39 VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__inv_2
XFILLER_15_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1110_ net46 VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__inv_2
XFILLER_53_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1041_ net45 VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__inv_2
X_0825_ g5_5\[1\] g4_5\[3\] VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__or2_1
X_0687_ _0376_ _0409_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__and2_1
X_0756_ _0049_ b0\[1\] net34 VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__and3b_1
XFILLER_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1308_ clknet_leaf_15_clk net121 _0159_ VGND VGND VPWR VPWR sum_9\[5\] sky130_fd_sc_hd__dfrtp_1
X_1239_ net39 VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__inv_2
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1024_ _0000_ _0636_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__nor2_1
XFILLER_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_28_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0808_ _0462_ _0464_ _0475_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_12_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0739_ pp3\[1\]\[2\] pp3\[4\]\[2\] VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__nand2_1
XFILLER_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold71 part0_7\[0\] VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd3_1
Xhold93 sum_9\[0\] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 part0_6\[4\] VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold82 sum_9\[7\] VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_41_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1007_ _0628_ _0629_ _0630_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__o21a_1
Xrebuffer14 _0580_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_22_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1487_ clknet_leaf_0_clk _0060_ _0338_ VGND VGND VPWR VPWR pp2\[2\]\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_52_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer5 net72 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dlygate4sd1_1
X_1410_ clknet_leaf_19_clk _0099_ _0261_ VGND VGND VPWR VPWR g2_4\[3\] sky130_fd_sc_hd__dfrtp_1
X_1341_ clknet_leaf_12_clk net134 _0192_ VGND VGND VPWR VPWR part2_7\[8\] sky130_fd_sc_hd__dfrtp_1
X_1272_ net35 VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__inv_2
XFILLER_51_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0987_ _0612_ _0621_ _0611_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_14_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Left_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0841_ pp3\[15\]\[2\] g5_5\[4\] VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__and2_1
XFILLER_41_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0772_ a0\[1\] b3\[1\] _0061_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__and3_1
X_0910_ _0567_ g1_5\[3\] g1_5\[2\] VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__and3b_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1186_ net35 VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__inv_2
X_1324_ clknet_leaf_15_clk _0015_ _0175_ VGND VGND VPWR VPWR mid_8\[5\] sky130_fd_sc_hd__dfrtp_1
X_1255_ net40 VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__inv_2
XFILLER_32_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1040_ net45 VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_48_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0824_ g5_5\[1\] g4_5\[3\] VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__nand2_1
X_0755_ b0\[0\] a0\[0\] VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__and2_1
X_0686_ _0376_ _0409_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__nor2_1
X_1169_ net44 VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__inv_2
X_1238_ net35 VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__inv_2
X_1307_ clknet_leaf_15_clk net126 _0158_ VGND VGND VPWR VPWR sum_9\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_22_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1023_ net231 _0568_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_44_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0807_ _0065_ _0489_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__nor2_1
X_0738_ pp3\[1\]\[2\] pp3\[4\]\[2\] VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0669_ _0396_ _0397_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__nor2_4
Xhold50 rst VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dlygate4sd3_1
Xhold94 sum_9\[10\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_35_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold72 pp2\[7\]\[0\] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 mid_8\[4\] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold83 g2_4\[0\] VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1006_ b3\[0\] a3\[1\] a3\[0\] b3\[1\] VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__a22o_1
Xrebuffer15 _0579_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer26 _0398_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_19_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1486_ clknet_leaf_0_clk _0059_ _0337_ VGND VGND VPWR VPWR pp2\[2\]\[1\] sky130_fd_sc_hd__dfrtp_1
Xclkbuf_leaf_19_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_52_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1340_ clknet_leaf_10_clk net207 _0191_ VGND VGND VPWR VPWR part2_8\[15\] sky130_fd_sc_hd__dfrtp_1
Xrebuffer6 net72 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dlygate4sd1_1
X_1271_ net36 VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__inv_2
X_0986_ _0615_ _0620_ _0614_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__o21ba_1
Xclkbuf_leaf_8_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_14_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1469_ clknet_leaf_5_clk _0109_ _0320_ VGND VGND VPWR VPWR pp3\[14\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_2_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0840_ pp3\[15\]\[2\] g5_5\[4\] VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__nor2_1
XFILLER_41_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0771_ _0061_ b3\[1\] net34 VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_11_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1323_ clknet_leaf_15_clk _0014_ _0174_ VGND VGND VPWR VPWR mid_8\[4\] sky130_fd_sc_hd__dfrtp_1
X_1185_ net38 VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__inv_2
X_1254_ net40 VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__inv_2
X_0969_ b2\[0\] a3\[0\] VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_25_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0823_ pp3\[15\]\[0\] _0494_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__xnor2_1
X_0685_ _0409_ _0410_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__and2_4
X_0754_ _0046_ _0457_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__nor2_1
X_1306_ clknet_leaf_16_clk net180 _0157_ VGND VGND VPWR VPWR sum_9\[3\] sky130_fd_sc_hd__dfrtp_1
X_1099_ net61 VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__inv_2
X_1168_ net43 VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__inv_2
X_1237_ net38 VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_30_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1022_ _0568_ _0635_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__nor2_1
X_0806_ _0483_ _0486_ _0488_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__nor3_1
X_0737_ _0446_ _0447_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__nor2_1
X_0668_ part1_7\[5\] part0_7\[5\] VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__nor2_4
XFILLER_52_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold40 b[3] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_20_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold95 sum_9\[13\] VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 sum_9\[12\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 sum_9\[1\] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 part0_6\[2\] VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 mid_8\[7\] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer16 _0387_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dlygate4sd1_1
X_1005_ _0628_ _0629_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__nor2_1
XFILLER_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput30 net30 VGND VGND VPWR VPWR product[6] sky130_fd_sc_hd__buf_2
XFILLER_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1485_ clknet_leaf_0_clk _0057_ _0336_ VGND VGND VPWR VPWR pp2\[2\]\[0\] sky130_fd_sc_hd__dfrtp_1
.ends
